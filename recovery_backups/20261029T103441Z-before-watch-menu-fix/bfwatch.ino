/*
 * bfwatch.ino
 *
 * BudFinder watch MVP for the LILYGO T-Watch S3 Plus.
 * Target library: Xinyuan-LilyGO/LilyGoLib (LVGL 9 build)
 * Target board:   LilyGo T-Watch-S3, correct radio revision selected
 *
 * Included now:
 *   - Battery-first watch face with automatic display-off/light sleep
 *   - Swipe-left app launcher with large touch targets
 *   - Stopwatch that continues while the display sleeps
 *   - Stopwatch laps, interval timer and low-power hardware step counter
 *   - Countdown timer with timer wake plus song/haptic alarm
 *   - Persistent RTC alarm with repeat modes and five-minute snooze
 *   - Persistent alert volume and an embedded, replaceable MP3 alarm
 *   - Session-based GNSS speedometer with max, average and trip distance
 *   - Battery diagnostics and full-white torch
 *   - Manual RTC clock setting
 *   - Guarded TV power-toggle remote for common LG, Samsung and Sony codes
 *   - Manual or scheduled, timeout-limited GNSS fixes
 *   - Cached position plus nearest-shop distance and true bearing
 *   - Full offline strain search with stockist lists and filtered map markers
 *   - Persistent GPS interval, screen timeout and brightness settings
 *   - Optional BMA423 raise-to-wake from light sleep
 *   - GPIO0 custom button returns home and randomises the watch-face shop
 *   - Offline Amsterdam map rendered from JPEG tiles stored in FFat
 *   - Touch panning, three zoom levels and coffeeshop/location overlays
 *   - Time-limited, single-SSID novelty Wi-Fi access point
 *   - Dependency-free USB serial map uploader
 *
 * Deliberately omitted:
 *   - Compass / watch-relative arrow (the watch has no magnetometer)
 *   - Continuous GNSS tracking
 *   - Bluetooth and LoRa
 *
 * Coffeeshop data is generated by generate_watch_data.py.
 */

#include <Arduino.h>
#include <LilyGoLib.h>
#include <LV_Helper.h>
#include <FFat.h>
#include <Preferences.h>
#include <WiFi.h>
#include <esp_sleep.h>
#include <esp_system.h>
#include <esp_timer.h>
#include <driver/rtc_io.h>
#include <IRremote.hpp>
#include <ctype.h>
#include <math.h>
#include <strings.h>
#include <time.h>

#include "src/libhelix-mp3/mp3dec.h"
#include "bfwatch_data.h"
#include "watch_map/map_config.h"
#include "watch_logos/logos_config.h"
#include "watchface_background.h"
#include "alert_audio.h"

// LVGL's streaming JPEG decoder has a 4 KiB work buffer and a deep draw call
// chain. Arduino-ESP32's default 8 KiB loop stack overflows while rendering
// four clipped map tiles, so give the UI task explicit headroom.
SET_LOOP_TASK_STACK_SIZE(20 * 1024);

// -----------------------------------------------------------------------------
// User-tunable settings
// -----------------------------------------------------------------------------

static constexpr uint8_t DEFAULT_SCREEN_BRIGHTNESS = 80; // 0..255, about 31%
static constexpr uint32_t GPS_AUTO_TIMEOUT_MS = 75000;
static constexpr uint32_t GPS_MANUAL_TIMEOUT_MS = 180000;
static constexpr uint32_t GPS_MAX_FIX_AGE_MS = 2000;
static constexpr uint32_t GPS_LIVE_REFRESH_MS = 3000;
static constexpr uint32_t GPS_FIX_SAVE_INTERVAL_MS = 60000;
static constexpr uint32_t GPS_POWER_SETTLE_MS = 350;
static constexpr uint32_t GPS_DATA_STALL_MS = 10000;
static constexpr uint32_t GPS_DIAGNOSTIC_INTERVAL_MS = 5000;
static constexpr uint8_t GPS_MAX_DATA_RESTARTS = 2;
static constexpr uint32_t AMSTERDAM_GPS_WARM_HOLD_MS = 10U * 60U * 1000U;
static constexpr uint8_t AMSTERDAM_GPS_MIN_BATTERY_PERCENT = 20;
static constexpr uint32_t JOKE_AP_DURATION_MS = 60000;
static constexpr uint32_t RANDOM_WATCH_SHOP_INTERVAL_MS = 5000;
static constexpr uint16_t MAP_VIEW_SIZE = 240;
static constexpr uint16_t MAP_UPLOAD_TIMEOUT_MS = 10000;
static constexpr size_t MAP_UPLOAD_BLOCK_SIZE = 128;
static constexpr uint32_t MAP_UPLOAD_IDLE_TIMEOUT_MS = 30000;
static constexpr size_t MAX_MAP_MOVABLES = 180;
static constexpr size_t MAX_MAP_TILES = 4;
static constexpr size_t MAX_MAP_PACK_FILES = 32;
static constexpr uint16_t COMPACT_LOGO_SIZE = 24;
static constexpr uint16_t STRAIN_MAP_SAFE_HALF_WIDTH = 100;
static constexpr uint16_t STRAIN_MAP_SAFE_HALF_HEIGHT = 60;
static constexpr size_t STRAIN_MAP_LOGO_MAX_STOCKISTS = 8;
static constexpr size_t STRAIN_SELECTION_BYTES = 96;
static constexpr size_t MAX_NAVIGATION_HISTORY = 8;
static constexpr uint8_t ALPHABET_BUCKET_COUNT = 27;
static constexpr uint8_t ALPHABET_OTHER_BUCKET = 26;

// Warm technical palette: espresso, walnut, copper and parchment.
static constexpr uint32_t THEME_BACKGROUND = 0x100C0A;
static constexpr uint32_t THEME_PANEL = 0x211711;
static constexpr uint32_t THEME_PANEL_RAISED = 0x2C1E16;
static constexpr uint32_t THEME_BUTTON = 0x3B291F;
static constexpr uint32_t THEME_BUTTON_PRESSED = 0x64432D;
static constexpr uint32_t THEME_BORDER = 0x705038;
static constexpr uint32_t THEME_ACCENT = 0xC9864A;
static constexpr uint32_t THEME_GOLD = 0xE4B96F;
static constexpr uint32_t THEME_TEXT = 0xF4E7D0;
static constexpr uint32_t THEME_MUTED = 0xBBA48C;
static constexpr uint32_t THEME_SUBTLE = 0x806B5B;
static constexpr uint32_t THEME_DANGER = 0x8A382E;
static constexpr uint32_t THEME_DANGER_PRESSED = 0xB65443;
static constexpr int16_t STATUS_BATTERY_X = 188;
static constexpr int16_t STATUS_BATTERY_Y = 6;
static constexpr int16_t STATUS_BATTERY_WIDTH = 46;
static constexpr int16_t STATUS_BATTERY_HEIGHT = 25;
static constexpr intptr_t ACTION_OPEN_APPS = 30000;
static constexpr intptr_t ACTION_MAP_BACK = 30001;

// -----------------------------------------------------------------------------
// State
// -----------------------------------------------------------------------------

enum class View : uint8_t {
    WATCH,
    MENU,
    NEARBY,
    SHOP,
    STRAINS,
    STRAIN_SHOPS,
    SPEEDOMETER,
    STOPWATCH,
    TIMER,
    ALARM,
    INTERVAL,
    STEPS,
    BATTERY,
    TORCH,
    GPS,
    MAP,
    CLOCK,
    IR,
    SETTINGS,
    WIFI_AP
};

struct NavigationState {
    View view;
    int16_t detailShopIndex;
    int32_t appsScrollOffset;
    int32_t menusScrollOffset;
    int32_t shopStrainScrollOffset;
    int32_t strainsScrollOffset;
    int32_t strainShopsScrollOffset;
    int32_t settingsScrollOffset;
    int8_t menusActiveGroup;
    uint8_t strainActiveLetter;
    bool menusGroupOpen;
    bool strainLetterOpen;
    bool strainFavouritesOpen;
    char selectedStrainName[STRAIN_SELECTION_BYTES];
};

static View previousNavigationView(View fallback);
static void navigateBack(View fallback);
static bool viewHasRunningState(View view);

enum class GpsUpdateMode : uint8_t {
    MANUAL,
    CONSTANT,
    MINUTES_2_5,
    MINUTES_5,
    AMSTERDAM,
    COUNT
};

enum class ClockField : uint8_t {
    YEAR,
    MONTH,
    DAY,
    HOUR,
    MINUTE
};

enum class TvProfile : uint8_t {
    LG,
    SAMSUNG,
    SONY,
    COUNT
};

enum class AlertMode : uint8_t {
    SILENT,
    VIBRATE,
    SOUND,
    BOTH,
    COUNT
};

enum class AlertSource : uint8_t {
    NONE,
    COUNTDOWN,
    CLOCK
};

enum class AlarmRepeat : uint8_t {
    ONCE,
    DAILY,
    WEEKDAYS,
    WEEKENDS,
    COUNT
};

enum class AlarmField : uint8_t {
    HOUR,
    MINUTE,
    MODE
};

enum class SpeedUnit : uint8_t {
    KPH,
    MPH,
    COUNT
};

enum class WatchShopMode : uint8_t {
    RANDOM,
    FAVOURITES,
    NEAREST,
    COUNT
};

struct CachedFix {
    uint32_t version;
    double latitude;
    double longitude;
    int64_t rtcEpoch;
};

static constexpr uint32_t FIX_VERSION = 1;
static constexpr uint64_t DEFAULT_TIMER_US = 0;
static constexpr uint8_t CUSTOM_HOME_BUTTON_PIN = 0;
static constexpr uint32_t CUSTOM_BUTTON_DEBOUNCE_MS = 250;
static constexpr uint32_t ALERT_REPEAT_MS = 1800;
static constexpr uint8_t ALERT_VOLUME_STEP = 20;
// The embedded song is mastered quietly. At 100% UI volume this supplies
// about +8 dB of digital gain; decoded samples are saturated below.
static constexpr uint16_t ALERT_AUDIO_GAIN_PERCENT = 250;
static constexpr uint32_t ALARM_SNOOZE_MINUTES = 5;
static constexpr uint32_t SPEED_REFRESH_MS = 500;
static constexpr size_t MAX_STOPWATCH_LAPS = 5;
static constexpr uint32_t SCREEN_TIMEOUT_OPTIONS_MS[] = {
    7000, 15000, 30000, 60000, 180000, 300000
};
static constexpr size_t SCREEN_TIMEOUT_OPTION_COUNT =
    sizeof(SCREEN_TIMEOUT_OPTIONS_MS) /
    sizeof(SCREEN_TIMEOUT_OPTIONS_MS[0]);

static View currentView = View::WATCH;
static View lastBuiltView = View::WATCH;
static NavigationState navigationHistory[MAX_NAVIGATION_HISTORY] = {};
static size_t navigationHistoryCount = 0;
static uint32_t lastActivityMs = 0;
static uint32_t lastUiRefreshMs = 0;
static uint32_t ignorePowerButtonUntilMs = 0;
static bool sleepRequested = false;
static bool screenGestureInstalled = false;
static bool mapStorageReady = false;
static bool mapPackageReady = false;
static bool logoPackageReady = false;
static bool menuPackageReady = false;
static bool mapUploadActive = false;
static uint32_t mapUploadLastActivityMs = 0;
static bool jokeApActive = false;
static uint32_t jokeApStartedMs = 0;
static const char *activeJokeSsid = nullptr;
static constexpr const char *JOKE_SSIDS[] = {
    "Budfinder.org_Find_Your_Strain",
    "Dont_Sleep_On_Budfinder.org"
};
static constexpr size_t JOKE_SSID_COUNT =
    sizeof(JOKE_SSIDS) / sizeof(JOKE_SSIDS[0]);

static lv_obj_t *primaryLabel = nullptr;
static lv_obj_t *secondaryLabel = nullptr;
static lv_obj_t *tertiaryLabel = nullptr;
static lv_obj_t *shopDistanceLabel = nullptr;
static lv_obj_t *batteryLabel = nullptr;
static lv_obj_t *runningAppsLabel = nullptr;
static lv_obj_t *audioTestButtonLabel = nullptr;
static lv_obj_t *statusLabel = nullptr;
static lv_obj_t *activeListFrame = nullptr;
static int32_t *activeListSavedOffset = nullptr;
static int32_t activeListRestoreOffset = 0;
static int32_t appsScrollOffset = 0;
static int32_t menusScrollOffset = 0;
static int32_t shopStrainScrollOffset = 0;
static int32_t strainsScrollOffset = 0;
static int32_t strainShopsScrollOffset = 0;
static int32_t settingsScrollOffset = 0;

static GpsUpdateMode gpsUpdateMode = GpsUpdateMode::MANUAL;
static uint8_t screenTimeoutIndex = 0;
static uint8_t screenBrightness = DEFAULT_SCREEN_BRIGHTNESS;
// Experimental until verified on physical hardware. Deliberately session-only
// and off after every reboot so the hardware RESET button is a recovery path.
static bool raiseToWakeEnabled = false;
static bool motionSensorReady = false;
static int64_t nextGpsUpdateUs = 0;
static bool gpsManualRequest = false;
static uint32_t lastGpsAcceptedMs = 0;
static uint32_t lastFixSavedMs = 0;

static bool stopwatchRunning = false;
static int64_t stopwatchStartedUs = 0;
static uint64_t stopwatchAccumulatedUs = 0;
static uint64_t stopwatchLapsUs[MAX_STOPWATCH_LAPS] = {};
static uint8_t stopwatchLapCount = 0;

static bool timerRunning = false;
static int64_t timerEndsUs = 0;
static uint64_t timerRemainingUs = DEFAULT_TIMER_US;
static bool timerAlarmVisible = false;

static AlertMode alertMode = AlertMode::BOTH;
static uint8_t alertVolumePercent = 60;
static AlertSource alertSource = AlertSource::NONE;
static bool alertRinging = false;
static uint32_t lastAlertPulseMs = 0;
static bool speakerReady = false;
static bool alertAudioPlaying = false;
static bool alertAudioLooping = false;
static uint32_t alertAudioRestartMs = 0;
static HMP3Decoder alertDecoder = nullptr;
static uint8_t *alertAudioReadPtr = nullptr;
static int alertAudioBytesRemaining = 0;
static int16_t *alertPcmBuffer = nullptr;

static bool clockAlarmEnabled = false;
static uint8_t clockAlarmHour = 8;
static uint8_t clockAlarmMinute = 0;
static AlarmRepeat clockAlarmRepeat = AlarmRepeat::DAILY;
static AlarmField alarmField = AlarmField::HOUR;
static int64_t alarmSnoozeEndsUs = 0;
static int64_t lastClockAlarmEpoch = 0;
static uint32_t lastClockAlarmPollMs = 0;

static bool intervalRunning = false;
static bool intervalWorkPhase = true;
static uint8_t intervalWorkMinutes = 25;
static uint8_t intervalBreakMinutes = 5;
static uint16_t intervalRounds = 0;
static int64_t intervalEndsUs = 0;
static uint64_t intervalRemainingUs = 25ULL * 60ULL * 1000000ULL;

static bool speedometerRunning = false;
static SpeedUnit speedUnit = SpeedUnit::KPH;
static WatchShopMode watchShopMode = WatchShopMode::RANDOM;
static double speedCurrentKph = 0.0;
static double speedMaximumKph = 0.0;
static double speedDistanceM = 0.0;
static int64_t speedStartedUs = 0;
static uint64_t speedAccumulatedUs = 0;
static uint32_t speedLastSampleMs = 0;

static bool customButtonWasDown = false;
static uint32_t customButtonLastActionMs = 0;

static bool gpsAcquiring = false;
static uint32_t gpsStartedMs = 0;
static uint32_t gpsCharsAtStart = 0;
static uint32_t gpsLastCharsProcessed = 0;
static uint32_t gpsLastDataMs = 0;
static uint32_t gpsLastDiagnosticMs = 0;
static uint8_t gpsDataRestartCount = 0;
static uint32_t gpsSerialBaud = 38400;
static char gpsStatus[160] = "GNSS is off";

static bool haveFix = false;
static double lastLatitude = 0.0;
static double lastLongitude = 0.0;
static int64_t lastFixEpoch = 0;

static bool haveNearest = false;
static const char *nearestName = nullptr;
static double nearestDistanceM = 0.0;
static double nearestBearingDeg = 0.0;
static int16_t nearestShopIndex = -1;
static int16_t detailShopIndex = -1;
static int16_t mapFocusedShopIndex = -1;
static int16_t rotatingWatchShopIndex = -1;
static uint32_t rotatingWatchShopChangedMs = 0;

static constexpr size_t MAX_FAVOURITE_SHOPS = 64;
static uint32_t favouriteShopHashes[MAX_FAVOURITE_SHOPS] = {};
static size_t favouriteShopCount = 0;
static constexpr size_t MAX_FAVOURITE_STRAINS = 64;
static uint32_t favouriteStrainHashes[MAX_FAVOURITE_STRAINS] = {};
static size_t favouriteStrainCount = 0;
static uint16_t shopDisplayOrder[BFWATCH_SHOP_COUNT] = {};
static uint16_t strainShopOrder[BFWATCH_SHOP_COUNT] = {};
static size_t strainShopCount = 0;
static char selectedStrainName[STRAIN_SELECTION_BYTES] = {};
static const char **strainCatalogNames = nullptr;
static uint32_t strainCatalogCount = 0;
static bool strainLetterOpen = false;
static bool strainFavouritesOpen = false;
static uint8_t strainActiveLetter = 0;
static bool menusGroupOpen = false;
// -2 is Favourites, -1 is All Shops, 0..26 are A-Z/#.
static int8_t menusActiveGroup = -1;

static bool clockEditorLoaded = false;
static uint16_t clockYear = 2026;
static uint8_t clockMonth = 1;
static uint8_t clockDay = 1;
static uint8_t clockHour = 12;
static uint8_t clockMinute = 0;
static ClockField clockField = ClockField::HOUR;

static TvProfile tvProfile = TvProfile::LG;

struct MapMovable {
    lv_obj_t *object;
    int16_t x;
    int16_t y;
};

struct MapMarkerPoint {
    int16_t x;
    int16_t y;
    int16_t anchorX;
    int16_t anchorY;
    uint16_t shopIndex;
    uint8_t size;
    uint8_t priority;
    bool useLogo;
    uint32_t fill;
    uint32_t border;
};

struct MapPackIndexHeader {
    char magic[8];
    uint32_t tileCount;
    uint32_t packCount;
};

struct MapPackEntry {
    uint8_t zoom;
    uint8_t reserved[3];
    int32_t x;
    int32_t y;
    uint16_t packId;
    uint16_t reserved2;
    uint32_t offset;
    uint32_t size;
};

struct MapPackedFile {
    File file;
    uint32_t base;
    uint32_t size;
    uint32_t position;
};

struct LogoIndexHeader {
    char magic[8];
    uint16_t width;
    uint16_t height;
    uint32_t shopCount;
    uint32_t uniqueCount;
    uint32_t dataBytes;
    uint32_t dataCrc32;
};

struct LogoIndexRecord {
    uint32_t identifierHash;
    uint32_t offset;
    uint32_t flags;
};

struct ExternalMenuHeader {
    char magic[8];
    uint32_t shopCount;
    uint32_t strainCount;
    uint32_t stringBytes;
    uint32_t payloadBytes;
    uint32_t payloadCrc32;
};

struct ExternalMenuShopRecord {
    uint32_t identifierHash;
    uint16_t strainOffset;
    uint16_t menuTotal;
    uint16_t strainCount;
    uint16_t reserved;
};

struct ExternalMenuStrainRecord {
    uint32_t nameOffset;
    uint16_t priceCents;
    uint8_t type;
    uint8_t flags;
};

struct MenuStrainView {
    const char *name;
    uint16_t priceCents;
    uint8_t type;
    uint8_t flags;
};

static_assert(sizeof(MapPackIndexHeader) == 16,
              "Map pack header layout changed");
static_assert(sizeof(MapPackEntry) == 24,
              "Map pack entry layout changed");
static_assert(sizeof(LogoIndexHeader) == 28,
              "Logo index header layout changed");
static_assert(sizeof(LogoIndexRecord) == 12,
              "Logo index record layout changed");
static_assert(sizeof(ExternalMenuHeader) == 28,
              "External menu header layout changed");
static_assert(sizeof(ExternalMenuShopRecord) == 12,
              "External menu shop layout changed");
static_assert(sizeof(ExternalMenuStrainRecord) == 8,
              "External menu strain layout changed");

static lv_obj_t *mapViewport = nullptr;
static lv_obj_t *mapStatusLabel = nullptr;
static MapMovable mapMovables[MAX_MAP_MOVABLES] = {};
static size_t mapMovableCount = 0;
static MapMarkerPoint mapMarkerPoints[BFWATCH_SHOP_COUNT + 1] = {};
static size_t mapMarkerPointCount = 0;
static uint8_t *mapOverlayBuffer = nullptr;
static uint32_t mapOverlayStride = 0;
static uint8_t mapZoom = BFWATCH_MAP_MAX_ZOOM;
static bool mapCenterInitialized = false;
static double mapCenterLatitude =
    BFWATCH_DEFAULT_LATITUDE_E6 / 1000000.0;
static double mapCenterLongitude =
    BFWATCH_DEFAULT_LONGITUDE_E6 / 1000000.0;
static double mapDragStartWorldX = 0.0;
static double mapDragStartWorldY = 0.0;
static lv_point_t mapDragStartPoint = {};
static bool mapDragging = false;
static bool mapFollowPosition = false;
static bool mapFocusRequested = false;
static bool mapStrainFilterActive = false;
static size_t mapFilteredStockistCount = 0;
static uint8_t mapLoadedTileCount = 0;
static uint8_t mapMissingTileCount = 0;
static MapPackEntry *mapPackEntries = nullptr;
static uint32_t mapPackEntryCount = 0;
static uint32_t mapPackFileCount = 0;
static lv_fs_drv_t mapPackFsDriver = {};
static LogoIndexRecord *logoIndexRecords = nullptr;
static uint32_t logoIndexRecordCount = 0;
static uint8_t *menuPackageBuffer = nullptr;
static ExternalMenuShopRecord *externalMenuShops = nullptr;
static ExternalMenuStrainRecord *externalMenuStrains = nullptr;
static char *externalMenuStrings = nullptr;
static uint32_t externalMenuShopCount = 0;
static uint32_t externalMenuStrainCount = 0;
static uint32_t externalMenuStringBytes = 0;
static uint8_t *mapLogoSpriteBuffer = nullptr;
static uint8_t *menuLogoBuffer = nullptr;
static bool menuLogoBufferReady = false;

static char mapUploadLine[144] = {};
static size_t mapUploadLineLength = 0;

// -----------------------------------------------------------------------------
// Forward declarations
// -----------------------------------------------------------------------------

static void buildCurrentView();
static void updateCurrentView(bool force = false);
static void markActivity();
static void enterLowPowerSleep();
static void startGpsFix(bool manualRequest = true);
static void stopGpsFix(const char *message);
static void pollGpsSchedule();
static void pollJokeAccessPoint();
static void pollCustomHomeButton();
static void calculateNearest();
static void gestureEvent(lv_event_t *event);
static void irPowerEvent(lv_event_t *event);
static void loadShopPreferences();
static void loadSettings();
static void saveSettings();
static void configureRaiseToWakeSensor();
static void mapDragEvent(lv_event_t *event);
static void pollMapUpload();
static const MapPackEntry *findMapPackEntry(
    uint8_t zoom, int32_t x, int32_t y);
static int32_t findLogoRecordIndex(uint32_t identifierHash);
static uint32_t shopIdentifierHash(size_t index);
static void shopCoordinates(
    size_t index, double &latitude, double &longitude);
static void configureClockAlarm();
static bool initializeSpeaker();
static bool startAlertAudio(bool loop);
static void stopAlertAudio();
static void serviceAlertAudio();
static void startAlert(AlertSource source);
static void stopAlert();
static void stopSpeedometer();
static const ExternalMenuShopRecord *externalMenuForShop(size_t shopIndex);
static void shopMenuCounts(
    size_t shopIndex, uint16_t &menuTotal, uint16_t &strainCount);
static bool shopMenuStrain(
    size_t shopIndex, uint16_t position, MenuStrainView &result);
static bool shopComesBefore(size_t left, size_t right);
static void unloadStrainCatalog();
static bool buildStrainCatalog();
static bool shopStrainOffer(
    size_t shopIndex, const char *strainName, MenuStrainView &result);
static bool shopStocksStrain(size_t shopIndex, const char *strainName);
static void rebuildStrainShopOrder();
static void openSelectedStrainMap();
static uint32_t updateCrc32(
    uint32_t crc, const uint8_t *data, size_t length);

// -----------------------------------------------------------------------------
// General helpers
// -----------------------------------------------------------------------------

static void clearNavigationHistory()
{
    navigationHistoryCount = 0;
}

static void rememberCurrentView()
{
    if (navigationHistoryCount > 0 &&
        navigationHistory[navigationHistoryCount - 1].view == currentView) {
        return;
    }
    if (navigationHistoryCount >= MAX_NAVIGATION_HISTORY) {
        memmove(
            navigationHistory,
            navigationHistory + 1,
            (MAX_NAVIGATION_HISTORY - 1) * sizeof(navigationHistory[0]));
        navigationHistoryCount = MAX_NAVIGATION_HISTORY - 1;
    }
    NavigationState &state =
        navigationHistory[navigationHistoryCount++];
    state = {};
    state.view = currentView;
    state.detailShopIndex = detailShopIndex;
    state.appsScrollOffset = appsScrollOffset;
    state.menusScrollOffset = menusScrollOffset;
    state.shopStrainScrollOffset = shopStrainScrollOffset;
    state.strainsScrollOffset = strainsScrollOffset;
    state.strainShopsScrollOffset = strainShopsScrollOffset;
    state.settingsScrollOffset = settingsScrollOffset;
    state.menusActiveGroup = menusActiveGroup;
    state.strainActiveLetter = strainActiveLetter;
    state.menusGroupOpen = menusGroupOpen;
    state.strainLetterOpen = strainLetterOpen;
    state.strainFavouritesOpen = strainFavouritesOpen;
    snprintf(
        state.selectedStrainName,
        sizeof(state.selectedStrainName),
        "%s", selectedStrainName);
}

static View previousNavigationView(View fallback)
{
    return navigationHistoryCount > 0
        ? navigationHistory[navigationHistoryCount - 1].view
        : fallback;
}

static void navigateBack(View fallback)
{
    if (navigationHistoryCount == 0) {
        currentView = fallback;
        buildCurrentView();
        return;
    }
    const NavigationState state =
        navigationHistory[--navigationHistoryCount];
    currentView = state.view;
    detailShopIndex = state.detailShopIndex;
    appsScrollOffset = state.appsScrollOffset;
    menusScrollOffset = state.menusScrollOffset;
    shopStrainScrollOffset = state.shopStrainScrollOffset;
    strainsScrollOffset = state.strainsScrollOffset;
    strainShopsScrollOffset = state.strainShopsScrollOffset;
    settingsScrollOffset = state.settingsScrollOffset;
    menusActiveGroup = state.menusActiveGroup;
    strainActiveLetter = state.strainActiveLetter;
    menusGroupOpen = state.menusGroupOpen;
    strainLetterOpen = state.strainLetterOpen;
    strainFavouritesOpen = state.strainFavouritesOpen;
    snprintf(
        selectedStrainName,
        sizeof(selectedStrainName),
        "%s", state.selectedStrainName);
    buildCurrentView();
}

static int64_t monotonicUs()
{
    return esp_timer_get_time();
}

static int64_t readRtcEpoch()
{
    struct tm now = {};
    instance.rtc.getDateTime(&now);
    if (now.tm_year + 1900 < 2020) {
        return 0;
    }
    now.tm_isdst = -1;
    return static_cast<int64_t>(mktime(&now));
}

static bool insideAmsterdam(double latitude, double longitude)
{
    return latitude >= BFWATCH_MAP_SOUTH &&
           latitude <= BFWATCH_MAP_NORTH &&
           longitude >= BFWATCH_MAP_WEST &&
           longitude <= BFWATCH_MAP_EAST;
}

static double mapWorldSize(uint8_t zoom)
{
    return static_cast<double>(BFWATCH_MAP_TILE_SIZE) *
           static_cast<double>(1UL << zoom);
}

static double longitudeToWorldX(double longitude, uint8_t zoom)
{
    return (longitude + 180.0) / 360.0 * mapWorldSize(zoom);
}

static double latitudeToWorldY(double latitude, uint8_t zoom)
{
    latitude = constrain(latitude, -85.05112878, 85.05112878);
    const double radians = latitude * M_PI / 180.0;
    return (1.0 - asinh(tan(radians)) / M_PI) * 0.5 *
           mapWorldSize(zoom);
}

static double worldXToLongitude(double worldX, uint8_t zoom)
{
    return worldX / mapWorldSize(zoom) * 360.0 - 180.0;
}

static double worldYToLatitude(double worldY, uint8_t zoom)
{
    const double mercator =
        M_PI * (1.0 - 2.0 * worldY / mapWorldSize(zoom));
    return atan(sinh(mercator)) * 180.0 / M_PI;
}

static uint8_t mapOverviewZoom()
{
    return static_cast<uint8_t>(constrain(
        14,
        static_cast<int>(BFWATCH_MAP_MIN_ZOOM),
        static_cast<int>(BFWATCH_MAP_MAX_ZOOM)));
}

static bool insideMapDetail(double latitude, double longitude)
{
    return !BFWATCH_MAP_HAS_DETAIL_BOUNDS ||
           (latitude >= BFWATCH_MAP_DETAIL_SOUTH &&
            latitude <= BFWATCH_MAP_DETAIL_NORTH &&
            longitude >= BFWATCH_MAP_DETAIL_WEST &&
            longitude <= BFWATCH_MAP_DETAIL_EAST);
}

static void clampMapCenter()
{
    const bool useDetail =
        BFWATCH_MAP_HAS_DETAIL_BOUNDS &&
        mapZoom == BFWATCH_MAP_DETAIL_ZOOM;
    const double west =
        useDetail ? BFWATCH_MAP_DETAIL_WEST : BFWATCH_MAP_WEST;
    const double south =
        useDetail ? BFWATCH_MAP_DETAIL_SOUTH : BFWATCH_MAP_SOUTH;
    const double east =
        useDetail ? BFWATCH_MAP_DETAIL_EAST : BFWATCH_MAP_EAST;
    const double north =
        useDetail ? BFWATCH_MAP_DETAIL_NORTH : BFWATCH_MAP_NORTH;

    const double westernX = longitudeToWorldX(west, mapZoom);
    const double easternX = longitudeToWorldX(east, mapZoom);
    const double northernY = latitudeToWorldY(north, mapZoom);
    const double southernY = latitudeToWorldY(south, mapZoom);

    double worldX = longitudeToWorldX(mapCenterLongitude, mapZoom);
    double worldY = latitudeToWorldY(mapCenterLatitude, mapZoom);
    // Clamp the chosen centre to the installed geographic area, rather than
    // requiring the entire 240px viewport to remain inside it. The previous
    // viewport-sized inset made wide strain maps appear to snap back because
    // some zoom levels allowed only a few pixels of centre movement.
    worldX = max(westernX, min(easternX, worldX));
    worldY = max(northernY, min(southernY, worldY));
    mapCenterLongitude = worldXToLongitude(worldX, mapZoom);
    mapCenterLatitude = worldYToLatitude(worldY, mapZoom);
}

static void resetMapCenter()
{
    if (haveFix && insideAmsterdam(lastLatitude, lastLongitude)) {
        if (BFWATCH_MAP_HAS_DETAIL_BOUNDS &&
            mapZoom == BFWATCH_MAP_DETAIL_ZOOM &&
            !insideMapDetail(lastLatitude, lastLongitude) &&
            mapZoom > BFWATCH_MAP_MIN_ZOOM) {
            --mapZoom;
        }
        mapCenterLatitude = lastLatitude;
        mapCenterLongitude = lastLongitude;
        mapFollowPosition = true;
    } else {
        mapCenterLatitude =
            BFWATCH_DEFAULT_LATITUDE_E6 / 1000000.0;
        mapCenterLongitude =
            BFWATCH_DEFAULT_LONGITUDE_E6 / 1000000.0;
        mapFollowPosition = false;
    }
    clampMapCenter();
    mapCenterInitialized = true;
}

static void focusMapOnCurrentLocation()
{
    if (!haveFix || !insideAmsterdam(lastLatitude, lastLongitude)) {
        return;
    }
    mapZoom = BFWATCH_MAP_MAX_ZOOM;
    if (BFWATCH_MAP_HAS_DETAIL_BOUNDS &&
        mapZoom == BFWATCH_MAP_DETAIL_ZOOM &&
        !insideMapDetail(lastLatitude, lastLongitude) &&
        mapZoom > BFWATCH_MAP_MIN_ZOOM) {
        --mapZoom;
    }
    mapCenterLatitude = lastLatitude;
    mapCenterLongitude = lastLongitude;
    mapFollowPosition = true;
    mapFocusedShopIndex = -1;
    clampMapCenter();
    mapCenterInitialized = true;
}

static void openOverviewMap()
{
    mapStrainFilterActive = false;
    mapFilteredStockistCount = 0;
    mapZoom = mapOverviewZoom();
    mapCenterLatitude =
        BFWATCH_DEFAULT_LATITUDE_E6 / 1000000.0;
    mapCenterLongitude =
        BFWATCH_DEFAULT_LONGITUDE_E6 / 1000000.0;
    mapFollowPosition = false;
    mapFocusedShopIndex = -1;
    clampMapCenter();
    mapCenterInitialized = true;
    currentView = View::MAP;
    buildCurrentView();
}

static void openSelectedStrainMap()
{
    if (selectedStrainName[0] == '\0') {
        currentView = View::STRAINS;
        buildCurrentView();
        return;
    }
    mapStrainFilterActive = true;
    mapFilteredStockistCount = 0;
    double minimumLatitude = 90.0;
    double maximumLatitude = -90.0;
    double minimumLongitude = 180.0;
    double maximumLongitude = -180.0;
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        if (!shopStocksStrain(index, selectedStrainName)) {
            continue;
        }
        double latitude = 0.0;
        double longitude = 0.0;
        shopCoordinates(index, latitude, longitude);
        minimumLatitude = min(minimumLatitude, latitude);
        maximumLatitude = max(maximumLatitude, latitude);
        minimumLongitude = min(minimumLongitude, longitude);
        maximumLongitude = max(maximumLongitude, longitude);
        ++mapFilteredStockistCount;
    }
    if (mapFilteredStockistCount > 0) {
        // Z16 is a deliberately cropped central-city detail layer. Strain
        // maps start no closer than Z15 so a stockist near that crop's edge
        // cannot be pushed underneath the fixed map controls.
        uint8_t highestZoom = min(
            static_cast<uint8_t>(15), BFWATCH_MAP_MAX_ZOOM);
        if (BFWATCH_MAP_HAS_DETAIL_BOUNDS &&
            highestZoom == BFWATCH_MAP_DETAIL_ZOOM &&
            (minimumLatitude < BFWATCH_MAP_DETAIL_SOUTH ||
             maximumLatitude > BFWATCH_MAP_DETAIL_NORTH ||
             minimumLongitude < BFWATCH_MAP_DETAIL_WEST ||
             maximumLongitude > BFWATCH_MAP_DETAIL_EAST) &&
            highestZoom > BFWATCH_MAP_MIN_ZOOM) {
            --highestZoom;
        }

        mapZoom = BFWATCH_MAP_MIN_ZOOM;
        for (int zoom = highestZoom;
             zoom >= static_cast<int>(BFWATCH_MAP_MIN_ZOOM);
             --zoom) {
            mapZoom = static_cast<uint8_t>(zoom);
            const double spanX =
                longitudeToWorldX(maximumLongitude, mapZoom) -
                longitudeToWorldX(minimumLongitude, mapZoom);
            const double spanY =
                latitudeToWorldY(minimumLatitude, mapZoom) -
                latitudeToWorldY(maximumLatitude, mapZoom);
            if (spanX <= STRAIN_MAP_SAFE_HALF_WIDTH * 2.0 &&
                spanY <= STRAIN_MAP_SAFE_HALF_HEIGHT * 2.0) {
                break;
            }
        }

        const double minimumWorldX =
            longitudeToWorldX(minimumLongitude, mapZoom);
        const double maximumWorldX =
            longitudeToWorldX(maximumLongitude, mapZoom);
        const double minimumWorldY =
            latitudeToWorldY(maximumLatitude, mapZoom);
        const double maximumWorldY =
            latitudeToWorldY(minimumLatitude, mapZoom);
        mapCenterLongitude = worldXToLongitude(
            (minimumWorldX + maximumWorldX) * 0.5, mapZoom);
        mapCenterLatitude = worldYToLatitude(
            (minimumWorldY + maximumWorldY) * 0.5, mapZoom);
    } else {
        mapZoom = mapOverviewZoom();
        mapCenterLatitude =
            BFWATCH_DEFAULT_LATITUDE_E6 / 1000000.0;
        mapCenterLongitude =
            BFWATCH_DEFAULT_LONGITUDE_E6 / 1000000.0;
    }
    mapFollowPosition = false;
    mapFocusedShopIndex = -1;
    clampMapCenter();
    mapCenterInitialized = true;
    Serial.printf(
        "Strain map: %s stockists=%u zoom=%u centre=%.6f,%.6f\n",
        selectedStrainName,
        static_cast<unsigned>(mapFilteredStockistCount),
        static_cast<unsigned>(mapZoom),
        mapCenterLatitude, mapCenterLongitude);
    currentView = View::MAP;
    buildCurrentView();
}

static void openShopOnMap(int16_t shopIndex)
{
    if (shopIndex < 0 ||
        shopIndex >= static_cast<int16_t>(BFWATCH_SHOP_COUNT)) {
        return;
    }
    shopCoordinates(
        static_cast<size_t>(shopIndex),
        mapCenterLatitude, mapCenterLongitude);
    mapZoom = BFWATCH_MAP_MAX_ZOOM;
    if (BFWATCH_MAP_HAS_DETAIL_BOUNDS &&
        mapZoom == BFWATCH_MAP_DETAIL_ZOOM &&
        !insideMapDetail(mapCenterLatitude, mapCenterLongitude) &&
        mapZoom > BFWATCH_MAP_MIN_ZOOM) {
        --mapZoom;
    }
    mapFollowPosition = false;
    mapFocusedShopIndex = shopIndex;
    clampMapCenter();
    mapCenterInitialized = true;
    currentView = View::MAP;
    buildCurrentView();
}

static void unloadMapPackIndex()
{
    if (mapPackEntries != nullptr) {
        free(mapPackEntries);
        mapPackEntries = nullptr;
    }
    mapPackEntryCount = 0;
    mapPackFileCount = 0;
}

static bool loadMapPackIndex()
{
    unloadMapPackIndex();
    if (!mapStorageReady || !FFat.exists("/map.idx")) {
        return false;
    }

    File index = FFat.open("/map.idx", FILE_READ);
    MapPackIndexHeader header = {};
    if (!index ||
        index.read(reinterpret_cast<uint8_t *>(&header), sizeof(header)) !=
            sizeof(header) ||
        memcmp(header.magic, "BFMIDX01", sizeof(header.magic)) != 0 ||
        header.tileCount != BFWATCH_MAP_TILE_COUNT ||
        header.packCount == 0 ||
        header.packCount > MAX_MAP_PACK_FILES) {
        index.close();
        return false;
    }

    const size_t entriesSize =
        static_cast<size_t>(header.tileCount) * sizeof(MapPackEntry);
    mapPackEntries =
        static_cast<MapPackEntry *>(ps_malloc(entriesSize));
    if (mapPackEntries == nullptr ||
        index.read(reinterpret_cast<uint8_t *>(mapPackEntries), entriesSize) !=
            entriesSize) {
        index.close();
        unloadMapPackIndex();
        return false;
    }
    index.close();

    for (uint32_t packId = 0; packId < header.packCount; ++packId) {
        char path[16];
        snprintf(path, sizeof(path), "/map%02u.bin",
                 static_cast<unsigned>(packId));
        if (!FFat.exists(path)) {
            unloadMapPackIndex();
            return false;
        }
    }
    for (uint32_t i = 0; i < header.tileCount; ++i) {
        if (mapPackEntries[i].packId >= header.packCount ||
            mapPackEntries[i].size == 0) {
            unloadMapPackIndex();
            return false;
        }
    }

    mapPackEntryCount = header.tileCount;
    mapPackFileCount = header.packCount;
    return true;
}

static const MapPackEntry *findMapPackEntry(
    uint8_t zoom, int32_t x, int32_t y)
{
    int32_t low = 0;
    int32_t high = static_cast<int32_t>(mapPackEntryCount) - 1;
    while (low <= high) {
        const int32_t middle = low + (high - low) / 2;
        const MapPackEntry &entry = mapPackEntries[middle];
        int comparison = static_cast<int>(zoom) -
                         static_cast<int>(entry.zoom);
        if (comparison == 0 && x != entry.x) {
            comparison = x < entry.x ? -1 : 1;
        }
        if (comparison == 0 && y != entry.y) {
            comparison = y < entry.y ? -1 : 1;
        }
        if (comparison == 0) {
            return &entry;
        }
        if (comparison < 0) {
            high = middle - 1;
        } else {
            low = middle + 1;
        }
    }
    return nullptr;
}

static bool mapFilesInstalled()
{
    return loadMapPackIndex();
}

static void unloadLogoIndex()
{
    if (logoIndexRecords != nullptr) {
        free(logoIndexRecords);
        logoIndexRecords = nullptr;
    }
    // Keep the PSRAM allocation so any currently displayed canvases retain a
    // valid backing store while a replacement logo package is uploaded.
    menuLogoBufferReady = false;
    logoIndexRecordCount = 0;
}

static bool loadLogoIndex()
{
    unloadLogoIndex();
    if (!mapStorageReady ||
        !FFat.exists("/logos.idx") ||
        !FFat.exists("/logos.bin")) {
        return false;
    }

    File index = FFat.open("/logos.idx", FILE_READ);
    LogoIndexHeader header = {};
    if (!index ||
        index.read(reinterpret_cast<uint8_t *>(&header), sizeof(header)) !=
            sizeof(header) ||
        memcmp(header.magic, "BFLGIDX1", sizeof(header.magic)) != 0 ||
        header.width != BFWATCH_LOGO_WIDTH ||
        header.height != BFWATCH_LOGO_HEIGHT ||
        header.shopCount != BFWATCH_LOGO_SHOP_COUNT ||
        header.shopCount != BFWATCH_SHOP_COUNT ||
        header.dataBytes != BFWATCH_LOGO_DATA_BYTES ||
        header.dataCrc32 != BFWATCH_LOGO_DATA_CRC32) {
        index.close();
        return false;
    }

    File data = FFat.open("/logos.bin", FILE_READ);
    const bool dataValid = data && data.size() == header.dataBytes;
    data.close();
    if (!dataValid) {
        index.close();
        return false;
    }

    const size_t recordsSize =
        static_cast<size_t>(header.shopCount) * sizeof(LogoIndexRecord);
    logoIndexRecords =
        static_cast<LogoIndexRecord *>(ps_malloc(recordsSize));
    if (logoIndexRecords == nullptr ||
        index.read(reinterpret_cast<uint8_t *>(logoIndexRecords),
                   recordsSize) != recordsSize) {
        index.close();
        unloadLogoIndex();
        return false;
    }
    index.close();

    const uint32_t spriteBytes =
        static_cast<uint32_t>(header.width) * header.height * 4U;
    uint32_t previousHash = 0;
    for (uint32_t i = 0; i < header.shopCount; ++i) {
        const LogoIndexRecord &record = logoIndexRecords[i];
        if ((i > 0 && record.identifierHash <= previousHash) ||
            record.offset > header.dataBytes ||
            spriteBytes > header.dataBytes - record.offset) {
            unloadLogoIndex();
            return false;
        }
        previousHash = record.identifierHash;
    }
    logoIndexRecordCount = header.shopCount;
    return true;
}

static int32_t findLogoRecordIndex(uint32_t identifierHash)
{
    int32_t low = 0;
    int32_t high = static_cast<int32_t>(logoIndexRecordCount) - 1;
    while (low <= high) {
        const int32_t middle = low + (high - low) / 2;
        const uint32_t candidate =
            logoIndexRecords[middle].identifierHash;
        if (candidate == identifierHash) {
            return middle;
        }
        if (identifierHash < candidate) {
            high = middle - 1;
        } else {
            low = middle + 1;
        }
    }
    return -1;
}

static void unloadMenuPackage()
{
    unloadStrainCatalog();
    if (menuPackageBuffer != nullptr) {
        free(menuPackageBuffer);
        menuPackageBuffer = nullptr;
    }
    externalMenuShops = nullptr;
    externalMenuStrains = nullptr;
    externalMenuStrings = nullptr;
    externalMenuShopCount = 0;
    externalMenuStrainCount = 0;
    externalMenuStringBytes = 0;
    menuPackageReady = false;
}

static int32_t findExternalMenuRecord(uint32_t identifierHash)
{
    int32_t low = 0;
    int32_t high = static_cast<int32_t>(externalMenuShopCount) - 1;
    while (low <= high) {
        const int32_t middle = low + (high - low) / 2;
        const uint32_t candidate =
            externalMenuShops[middle].identifierHash;
        if (candidate == identifierHash) {
            return middle;
        }
        if (identifierHash < candidate) {
            high = middle - 1;
        } else {
            low = middle + 1;
        }
    }
    return -1;
}

static bool loadMenuPackage()
{
    unloadMenuPackage();
    if (!mapStorageReady || !FFat.exists("/menus.bin")) {
        return false;
    }

    File file = FFat.open("/menus.bin", FILE_READ);
    ExternalMenuHeader header = {};
    if (!file ||
        file.read(reinterpret_cast<uint8_t *>(&header), sizeof(header)) !=
            sizeof(header) ||
        memcmp(header.magic, "BFMENU01", sizeof(header.magic)) != 0 ||
        header.shopCount != BFWATCH_SHOP_COUNT ||
        header.strainCount > 65535 ||
        header.stringBytes == 0 || header.stringBytes > 1024 * 1024) {
        file.close();
        return false;
    }

    const size_t shopBytes =
        static_cast<size_t>(header.shopCount) *
        sizeof(ExternalMenuShopRecord);
    const size_t strainBytes =
        static_cast<size_t>(header.strainCount) *
        sizeof(ExternalMenuStrainRecord);
    const size_t expectedPayload =
        shopBytes + strainBytes + header.stringBytes;
    if (header.payloadBytes != expectedPayload ||
        static_cast<size_t>(file.size()) !=
            sizeof(header) + expectedPayload) {
        file.close();
        return false;
    }

    menuPackageBuffer = static_cast<uint8_t *>(ps_malloc(expectedPayload));
    if (menuPackageBuffer == nullptr ||
        file.read(menuPackageBuffer, expectedPayload) != expectedPayload) {
        file.close();
        unloadMenuPackage();
        return false;
    }
    file.close();
    const uint32_t crc =
        updateCrc32(0xFFFFFFFFUL, menuPackageBuffer, expectedPayload) ^
        0xFFFFFFFFUL;
    if (crc != header.payloadCrc32) {
        unloadMenuPackage();
        return false;
    }

    externalMenuShops =
        reinterpret_cast<ExternalMenuShopRecord *>(menuPackageBuffer);
    externalMenuStrains = reinterpret_cast<ExternalMenuStrainRecord *>(
        menuPackageBuffer + shopBytes);
    externalMenuStrings = reinterpret_cast<char *>(
        menuPackageBuffer + shopBytes + strainBytes);
    externalMenuShopCount = header.shopCount;
    externalMenuStrainCount = header.strainCount;
    externalMenuStringBytes = header.stringBytes;

    uint32_t previousHash = 0;
    for (uint32_t index = 0; index < externalMenuShopCount; ++index) {
        const ExternalMenuShopRecord &shop = externalMenuShops[index];
        if ((index > 0 && shop.identifierHash <= previousHash) ||
            shop.strainOffset > externalMenuStrainCount ||
            shop.strainCount >
                externalMenuStrainCount - shop.strainOffset ||
            shop.strainCount != shop.menuTotal) {
            unloadMenuPackage();
            return false;
        }
        previousHash = shop.identifierHash;
    }
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        if (findExternalMenuRecord(shopIdentifierHash(index)) < 0) {
            unloadMenuPackage();
            return false;
        }
    }
    for (uint32_t index = 0; index < externalMenuStrainCount; ++index) {
        const uint32_t offset = externalMenuStrains[index].nameOffset;
        if (offset >= externalMenuStringBytes ||
            memchr(externalMenuStrings + offset, '\0',
                   externalMenuStringBytes - offset) == nullptr) {
            unloadMenuPackage();
            return false;
        }
    }
    menuPackageReady = true;
    return true;
}

static const ExternalMenuShopRecord *externalMenuForShop(size_t shopIndex)
{
    if (!menuPackageReady || shopIndex >= BFWATCH_SHOP_COUNT) {
        return nullptr;
    }
    const int32_t record =
        findExternalMenuRecord(shopIdentifierHash(shopIndex));
    return record >= 0 ? &externalMenuShops[record] : nullptr;
}

static void shopMenuCounts(
    size_t shopIndex, uint16_t &menuTotal, uint16_t &strainCount)
{
    const ExternalMenuShopRecord *external =
        externalMenuForShop(shopIndex);
    if (external != nullptr) {
        menuTotal = external->menuTotal;
        strainCount = external->strainCount;
        return;
    }
    const WatchShopRecord &compiled = BFWATCH_SHOPS[shopIndex];
    menuTotal = compiled.menuTotal;
    strainCount = compiled.strainCount;
}

static bool shopMenuStrain(
    size_t shopIndex, uint16_t position, MenuStrainView &result)
{
    const ExternalMenuShopRecord *external =
        externalMenuForShop(shopIndex);
    if (external != nullptr) {
        if (position >= external->strainCount) {
            return false;
        }
        const ExternalMenuStrainRecord &strain =
            externalMenuStrains[external->strainOffset + position];
        result = {
            externalMenuStrings + strain.nameOffset,
            strain.priceCents,
            strain.type,
            strain.flags,
        };
        return true;
    }

    const WatchShopRecord &shop = BFWATCH_SHOPS[shopIndex];
    if (position >= shop.strainCount) {
        return false;
    }
    const WatchStrainRecord &strain =
        BFWATCH_STRAINS[shop.strainOffset + position];
    result = {
        bfwatchString(strain.nameOffset),
        strain.priceCents,
        strain.type,
        strain.flags,
    };
    return true;
}

static void unloadStrainCatalog()
{
    if (strainCatalogNames != nullptr) {
        free(strainCatalogNames);
        strainCatalogNames = nullptr;
    }
    strainCatalogCount = 0;
    strainLetterOpen = false;
    strainFavouritesOpen = false;
    strainActiveLetter = 0;
    strainsScrollOffset = 0;
    strainShopsScrollOffset = 0;
    strainShopCount = 0;
}

static int compareStrainCatalogNames(const void *left, const void *right)
{
    const char *leftName =
        *static_cast<const char *const *>(left);
    const char *rightName =
        *static_cast<const char *const *>(right);
    return strcasecmp(leftName, rightName);
}

static uint8_t alphabetBucket(const char *name)
{
    if (name == nullptr) {
        return ALPHABET_OTHER_BUCKET;
    }
    while (*name != '\0' &&
           isspace(static_cast<unsigned char>(*name))) {
        ++name;
    }
    const int first = toupper(static_cast<unsigned char>(*name));
    return first >= 'A' && first <= 'Z'
        ? static_cast<uint8_t>(first - 'A')
        : ALPHABET_OTHER_BUCKET;
}

static bool buildStrainCatalog()
{
    if (strainCatalogNames != nullptr) {
        return true;
    }
    // Search must never claim completeness from the compact compiled fallback.
    if (!menuPackageReady || externalMenuStrainCount == 0) {
        return false;
    }

    const size_t bytes =
        static_cast<size_t>(externalMenuStrainCount) *
        sizeof(*strainCatalogNames);
    strainCatalogNames =
        static_cast<const char **>(ps_malloc(bytes));
    if (strainCatalogNames == nullptr) {
        return false;
    }

    uint32_t count = 0;
    for (size_t shopIndex = 0;
         shopIndex < BFWATCH_SHOP_COUNT; ++shopIndex) {
        uint16_t menuTotal = 0;
        uint16_t strainCount = 0;
        shopMenuCounts(shopIndex, menuTotal, strainCount);
        for (uint16_t position = 0; position < strainCount; ++position) {
            MenuStrainView strain = {};
            if (shopMenuStrain(shopIndex, position, strain) &&
                strain.name != nullptr && strain.name[0] != '\0') {
                strainCatalogNames[count++] = strain.name;
            }
        }
    }
    if (count != externalMenuStrainCount) {
        unloadStrainCatalog();
        return false;
    }

    qsort(strainCatalogNames, count, sizeof(*strainCatalogNames),
          compareStrainCatalogNames);
    uint32_t uniqueCount = 0;
    for (uint32_t index = 0; index < count; ++index) {
        if (uniqueCount == 0 ||
            strcasecmp(strainCatalogNames[index],
                       strainCatalogNames[uniqueCount - 1]) != 0) {
            strainCatalogNames[uniqueCount++] =
                strainCatalogNames[index];
        }
    }
    strainCatalogCount = uniqueCount;
    if (selectedStrainName[0] != '\0') {
        for (uint32_t index = 0; index < strainCatalogCount; ++index) {
            if (strcasecmp(
                    strainCatalogNames[index], selectedStrainName) == 0) {
                strainActiveLetter =
                    alphabetBucket(strainCatalogNames[index]);
                break;
            }
        }
    }
    return strainCatalogCount > 0;
}

static bool shopStrainOffer(
    size_t shopIndex, const char *strainName, MenuStrainView &result)
{
    if (strainName == nullptr || strainName[0] == '\0') {
        return false;
    }
    uint16_t menuTotal = 0;
    uint16_t strainCount = 0;
    shopMenuCounts(shopIndex, menuTotal, strainCount);
    for (uint16_t position = 0; position < strainCount; ++position) {
        MenuStrainView strain = {};
        if (shopMenuStrain(shopIndex, position, strain) &&
            strcasecmp(strain.name, strainName) == 0) {
            result = strain;
            return true;
        }
    }
    return false;
}

static bool shopStocksStrain(size_t shopIndex, const char *strainName)
{
    MenuStrainView ignored = {};
    return shopStrainOffer(shopIndex, strainName, ignored);
}

static void rebuildStrainShopOrder()
{
    strainShopCount = 0;
    if (selectedStrainName[0] == '\0') {
        return;
    }
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        if (shopStocksStrain(index, selectedStrainName)) {
            strainShopOrder[strainShopCount++] =
                static_cast<uint16_t>(index);
        }
    }
    for (size_t index = 1; index < strainShopCount; ++index) {
        const uint16_t value = strainShopOrder[index];
        size_t position = index;
        while (position > 0 &&
               shopComesBefore(value, strainShopOrder[position - 1])) {
            strainShopOrder[position] =
                strainShopOrder[position - 1];
            --position;
        }
        strainShopOrder[position] = value;
    }
}

static bool mapPackFsReady(lv_fs_drv_t *driver)
{
    (void)driver;
    return mapStorageReady && mapPackEntries != nullptr;
}

static void *mapPackFsOpen(
    lv_fs_drv_t *driver, const char *path, lv_fs_mode_t mode)
{
    (void)driver;
    if (!(mode & LV_FS_MODE_RD) || mapPackEntries == nullptr) {
        return nullptr;
    }

    while (*path == '/') {
        ++path;
    }
    unsigned zoom = 0;
    long x = 0;
    long y = 0;
    int consumed = 0;
    if (sscanf(path, "%u/%ld/%ld.jpg%n",
               &zoom, &x, &y, &consumed) != 3 ||
        path[consumed] != '\0' || zoom > UINT8_MAX) {
        return nullptr;
    }
    const MapPackEntry *entry = findMapPackEntry(
        static_cast<uint8_t>(zoom),
        static_cast<int32_t>(x),
        static_cast<int32_t>(y));
    if (entry == nullptr) {
        return nullptr;
    }

    MapPackedFile *handle = new MapPackedFile();
    if (handle == nullptr) {
        return nullptr;
    }
    char packPath[16];
    snprintf(packPath, sizeof(packPath), "/map%02u.bin",
             static_cast<unsigned>(entry->packId));
    handle->file = FFat.open(packPath, FILE_READ);
    handle->base = entry->offset;
    handle->size = entry->size;
    handle->position = 0;
    if (!handle->file || !handle->file.seek(handle->base)) {
        handle->file.close();
        delete handle;
        return nullptr;
    }
    return handle;
}

static lv_fs_res_t mapPackFsClose(lv_fs_drv_t *driver, void *filePointer)
{
    (void)driver;
    MapPackedFile *handle = static_cast<MapPackedFile *>(filePointer);
    if (handle == nullptr) {
        return LV_FS_RES_INV_PARAM;
    }
    handle->file.close();
    delete handle;
    return LV_FS_RES_OK;
}

static lv_fs_res_t mapPackFsRead(
    lv_fs_drv_t *driver, void *filePointer, void *buffer,
    uint32_t bytesToRead, uint32_t *bytesRead)
{
    (void)driver;
    MapPackedFile *handle = static_cast<MapPackedFile *>(filePointer);
    if (handle == nullptr || buffer == nullptr) {
        return LV_FS_RES_INV_PARAM;
    }
    const uint32_t remaining = handle->size - handle->position;
    const uint32_t requested = min(bytesToRead, remaining);
    if (!handle->file.seek(handle->base + handle->position)) {
        return LV_FS_RES_FS_ERR;
    }
    const size_t count = handle->file.read(
        static_cast<uint8_t *>(buffer), requested);
    handle->position += count;
    if (bytesRead != nullptr) {
        *bytesRead = count;
    }
    return count == requested ? LV_FS_RES_OK : LV_FS_RES_FS_ERR;
}

static lv_fs_res_t mapPackFsSeek(
    lv_fs_drv_t *driver, void *filePointer, uint32_t position,
    lv_fs_whence_t whence)
{
    (void)driver;
    MapPackedFile *handle = static_cast<MapPackedFile *>(filePointer);
    if (handle == nullptr) {
        return LV_FS_RES_INV_PARAM;
    }
    uint64_t target = position;
    if (whence == LV_FS_SEEK_CUR) {
        target += handle->position;
    } else if (whence == LV_FS_SEEK_END) {
        target += handle->size;
    }
    if (target > handle->size) {
        return LV_FS_RES_INV_PARAM;
    }
    handle->position = static_cast<uint32_t>(target);
    return LV_FS_RES_OK;
}

static lv_fs_res_t mapPackFsTell(
    lv_fs_drv_t *driver, void *filePointer, uint32_t *position)
{
    (void)driver;
    MapPackedFile *handle = static_cast<MapPackedFile *>(filePointer);
    if (handle == nullptr || position == nullptr) {
        return LV_FS_RES_INV_PARAM;
    }
    *position = handle->position;
    return LV_FS_RES_OK;
}

static void registerMapPackFileSystem()
{
    lv_fs_drv_init(&mapPackFsDriver);
    mapPackFsDriver.letter = 'P';
    mapPackFsDriver.ready_cb = mapPackFsReady;
    mapPackFsDriver.open_cb = mapPackFsOpen;
    mapPackFsDriver.close_cb = mapPackFsClose;
    mapPackFsDriver.read_cb = mapPackFsRead;
    mapPackFsDriver.seek_cb = mapPackFsSeek;
    mapPackFsDriver.tell_cb = mapPackFsTell;
    lv_fs_drv_register(&mapPackFsDriver);
}

static void markActivity()
{
    lastActivityMs = millis();
}

static void formatDuration(uint64_t totalMs, bool showTenths,
                           char *buffer, size_t bufferSize)
{
    const uint32_t hours = totalMs / 3600000ULL;
    const uint32_t minutes = (totalMs / 60000ULL) % 60ULL;
    const uint32_t seconds = (totalMs / 1000ULL) % 60ULL;
    const uint32_t tenths = (totalMs / 100ULL) % 10ULL;

    if (showTenths) {
        snprintf(buffer, bufferSize, "%02u:%02u:%02u.%u",
                 hours, minutes, seconds, tenths);
    } else {
        snprintf(buffer, bufferSize, "%02u:%02u:%02u",
                 hours, minutes, seconds);
    }
}

static void formatDistance(double meters, char *buffer, size_t bufferSize)
{
    if (speedUnit == SpeedUnit::MPH) {
        const double miles = meters / 1609.344;
        if (meters < 160.9344) {
            snprintf(
                buffer, bufferSize, "%.0f ft", meters * 3.280839895);
        } else if (miles < 100.0) {
            snprintf(buffer, bufferSize, "%.1f mi", miles);
        } else {
            snprintf(buffer, bufferSize, "%.0f mi", miles);
        }
    } else if (meters < 1000.0) {
        snprintf(buffer, bufferSize, "%.0f m", meters);
    } else if (meters < 100000.0) {
        snprintf(buffer, bufferSize, "%.1f km", meters / 1000.0);
    } else {
        snprintf(buffer, bufferSize, "%.0f km", meters / 1000.0);
    }
}

static const char *alertModeName()
{
    switch (alertMode) {
    case AlertMode::SILENT:  return "SILENT";
    case AlertMode::VIBRATE: return "VIBRATE";
    case AlertMode::SOUND:   return "SOUND";
    case AlertMode::BOTH:    return "SOUND + VIBE";
    case AlertMode::COUNT:   break;
    }
    return "SOUND + VIBE";
}

static const char *alarmRepeatName()
{
    switch (clockAlarmRepeat) {
    case AlarmRepeat::ONCE:     return "ONCE";
    case AlarmRepeat::DAILY:    return "DAILY";
    case AlarmRepeat::WEEKDAYS: return "WEEKDAYS";
    case AlarmRepeat::WEEKENDS: return "WEEKENDS";
    case AlarmRepeat::COUNT:    break;
    }
    return "DAILY";
}

static const char *speedUnitName()
{
    return speedUnit == SpeedUnit::MPH ? "MPH" : "KM/H";
}

static const char *watchShopModeName()
{
    switch (watchShopMode) {
    case WatchShopMode::RANDOM:     return "RANDOM";
    case WatchShopMode::FAVOURITES: return "FAVOURITES";
    case WatchShopMode::NEAREST:    return "NEAREST";
    case WatchShopMode::COUNT:      break;
    }
    return "RANDOM";
}

static bool alertUsesSound()
{
    return alertMode == AlertMode::SOUND ||
           alertMode == AlertMode::BOTH;
}

static bool alertUsesVibration()
{
    return alertMode == AlertMode::VIBRATE ||
           alertMode == AlertMode::BOTH;
}

static bool initializeSpeaker()
{
#ifdef USING_PCM_AMPLIFIER
    static constexpr uint32_t AUDIO_SAMPLE_RATE = 44100;
    if (!instance.initAmplifier()) {
        return false;
    }
    return instance.player.configureTX(
        AUDIO_SAMPLE_RATE,
        I2S_DATA_BIT_WIDTH_16BIT,
        I2S_SLOT_MODE_STEREO);
#else
    return false;
#endif
}

static size_t writeTone(uint16_t frequency, uint16_t durationMs)
{
#ifdef USING_PCM_AMPLIFIER
    static constexpr uint32_t AUDIO_SAMPLE_RATE = 44100;
    // Duplicate every sample into left and right. The MAX98357A board can be
    // strapped to either I2S channel, so this guarantees an audible signal.
    int16_t samples[256 * 2];
    uint32_t remainingFrames =
        static_cast<uint32_t>(durationMs) * AUDIO_SAMPLE_RATE / 1000U;
    size_t totalWritten = 0;
    double phase = 0.0;
    const double step =
        2.0 * M_PI * static_cast<double>(frequency) /
        AUDIO_SAMPLE_RATE;
    while (remainingFrames > 0) {
        const size_t frames =
            remainingFrames < 256U ? remainingFrames : 256U;
        for (size_t index = 0; index < frames; ++index) {
            const int16_t sample =
                static_cast<int16_t>(16000.0 * sin(phase));
            samples[index * 2] = sample;
            samples[index * 2 + 1] = sample;
            phase += step;
            if (phase >= 2.0 * M_PI) {
                phase -= 2.0 * M_PI;
            }
        }
        const size_t wanted = frames * 2 * sizeof(samples[0]);
        const size_t written = instance.player.write(
            reinterpret_cast<uint8_t *>(samples),
            wanted);
        totalWritten += written;
        if (written != wanted) {
            break;
        }
        remainingFrames -= frames;
    }
    return totalWritten;
#else
    (void)frequency;
    (void)durationMs;
    return 0;
#endif
}

static bool startAlertAudio(bool loop)
{
    if (!alertUsesSound()) {
        return false;
    }
    stopAlertAudio();
    if (!speakerReady) {
        speakerReady = initializeSpeaker();
    }
    if (!speakerReady) {
        return false;
    }
    if (alertDecoder == nullptr) {
        alertDecoder = MP3InitDecoder();
    }
    if (alertDecoder == nullptr) {
        Serial.println("BFWatch audio: MP3 decoder allocation failed");
        return false;
    }
    if (alertPcmBuffer == nullptr) {
        const size_t samples =
            MAX_NCHAN * MAX_NGRAN * MAX_NSAMP;
        alertPcmBuffer = static_cast<int16_t *>(
            ps_malloc(samples * sizeof(int16_t)));
    }
    if (alertPcmBuffer == nullptr) {
        MP3FreeDecoder(alertDecoder);
        alertDecoder = nullptr;
        Serial.println("BFWatch audio: PCM PSRAM allocation failed");
        return false;
    }

    alertAudioReadPtr =
        const_cast<uint8_t *>(BFWATCH_ALERT_MP3);
    alertAudioBytesRemaining =
        static_cast<int>(BFWATCH_ALERT_MP3_BYTES);
    alertAudioPlaying = true;
    alertAudioLooping = loop;
    alertAudioRestartMs = 0;
    instance.powerControl(POWER_SPEAK, true);
    delay(75);
    Serial.printf("BFWatch audio: Totaka started at %u%%\n",
                  static_cast<unsigned>(alertVolumePercent));
    setLabel(audioTestButtonLabel, "STOP");
    return true;
}

static void stopAlertAudio()
{
    alertAudioLooping = false;
    alertAudioRestartMs = 0;
    if (alertDecoder != nullptr) {
        MP3FreeDecoder(alertDecoder);
        alertDecoder = nullptr;
    }
    alertAudioReadPtr = nullptr;
    alertAudioBytesRemaining = 0;
    alertAudioPlaying = false;
    delay(5);
    instance.powerControl(POWER_SPEAK, false);
    setLabel(audioTestButtonLabel, "TEST");
}

static void serviceAlertAudio()
{
    if (alertAudioPlaying && alertDecoder != nullptr &&
        alertAudioReadPtr != nullptr &&
        alertAudioBytesRemaining > 0) {
        const int offset = MP3FindSyncWord(
            alertAudioReadPtr, alertAudioBytesRemaining);
        if (offset < 0) {
            alertAudioBytesRemaining = 0;
        } else {
            alertAudioReadPtr += offset;
            alertAudioBytesRemaining -= offset;
            const int error = MP3Decode(
                alertDecoder, &alertAudioReadPtr,
                &alertAudioBytesRemaining,
                alertPcmBuffer, 0);
            if (error == ERR_MP3_NONE) {
                MP3FrameInfo info = {};
                MP3GetLastFrameInfo(alertDecoder, &info);
                if (info.bitsPerSample != 16 ||
                    info.outputSamps <= 0 ||
                    info.outputSamps >
                        MAX_NCHAN * MAX_NGRAN * MAX_NSAMP ||
                    (info.nChans != 1 && info.nChans != 2)) {
                    Serial.println("BFWatch audio: invalid MP3 frame");
                    alertAudioBytesRemaining = 0;
                } else {
                    int outputSamples = info.outputSamps;
                    if (info.nChans == 1) {
                        for (int index = outputSamples - 1;
                             index >= 0; --index) {
                            alertPcmBuffer[index * 2] =
                                alertPcmBuffer[index];
                            alertPcmBuffer[index * 2 + 1] =
                                alertPcmBuffer[index];
                        }
                        outputSamples *= 2;
                    }
                    for (int index = 0;
                         index < outputSamples; ++index) {
                        const int32_t scaled =
                            static_cast<int32_t>(
                                alertPcmBuffer[index]) *
                            alertVolumePercent *
                            ALERT_AUDIO_GAIN_PERCENT / 10000;
                        alertPcmBuffer[index] =
                            static_cast<int16_t>(
                                max(
                                    static_cast<int32_t>(INT16_MIN),
                                    min(
                                        static_cast<int32_t>(INT16_MAX),
                                        scaled)));
                    }
                    if (instance.player.txSampleRate() !=
                            static_cast<uint32_t>(info.samprate) &&
                        !instance.player.configureTX(
                            info.samprate,
                            I2S_DATA_BIT_WIDTH_16BIT,
                            I2S_SLOT_MODE_STEREO)) {
                        Serial.println(
                            "BFWatch audio: sample-rate setup failed");
                        alertAudioBytesRemaining = 0;
                    } else {
                        const size_t wanted =
                            static_cast<size_t>(outputSamples) *
                            sizeof(int16_t);
                        const size_t written = instance.player.write(
                            reinterpret_cast<uint8_t *>(
                                alertPcmBuffer),
                            wanted);
                        if (written != wanted) {
                            Serial.println(
                                "BFWatch audio: PCM write failed");
                            alertAudioBytesRemaining = 0;
                        }
                    }
                }
            } else if (error != ERR_MP3_MAINDATA_UNDERFLOW) {
                Serial.printf(
                    "BFWatch audio: MP3 decode error %d\n", error);
                alertAudioBytesRemaining = 0;
            }
        }
    }

    if (alertAudioPlaying &&
        alertAudioBytesRemaining <= 0) {
        const bool shouldLoop =
            alertAudioLooping && alertRinging;
        if (alertDecoder != nullptr) {
            MP3FreeDecoder(alertDecoder);
            alertDecoder = nullptr;
        }
        alertAudioReadPtr = nullptr;
        alertAudioPlaying = false;
        delay(25);
        instance.powerControl(POWER_SPEAK, false);
        if (shouldLoop) {
            alertAudioRestartMs = millis() + 700U;
        } else {
            alertAudioLooping = false;
            setLabel(audioTestButtonLabel, "TEST");
        }
    }

    if (!alertAudioPlaying && alertAudioLooping &&
        alertRinging && alertAudioRestartMs != 0 &&
        static_cast<int32_t>(millis() - alertAudioRestartMs) >= 0) {
        startAlertAudio(true);
    }
}

static void playAlertPulse()
{
    if (alertUsesVibration()) {
        instance.vibrator();
    }
    if (!alertUsesSound()) {
        return;
    }
    if (startAlertAudio(false)) {
        return;
    }

    // Retain a compact synthesized fallback if MP3 decoding cannot start.
    if (!speakerReady) {
        speakerReady = initializeSpeaker();
    }
    if (!speakerReady) {
        Serial.println("BFWatch audio: amplifier initialization failed");
        return;
    }
    instance.powerControl(POWER_SPEAK, true);
    delay(100);
    const size_t firstWritten = writeTone(880, 120);
    delay(45);
    const size_t secondWritten = writeTone(1175, 150);
    delay(100);
    instance.powerControl(POWER_SPEAK, false);
    const size_t expected =
        (120U + 150U) * 44100U / 1000U *
        2U * sizeof(int16_t);
    Serial.printf(
        "BFWatch audio: wrote=%u/%u error=%d rate=%u\n",
        static_cast<unsigned>(firstWritten + secondWritten),
        static_cast<unsigned>(expected),
        instance.player.lastError(),
        static_cast<unsigned>(instance.player.txSampleRate()));
}

static void startAlert(AlertSource source)
{
    alertSource = source;
    alertRinging = true;
    lastAlertPulseMs = millis();
    if (alertUsesVibration()) {
        instance.vibrator();
    }
    if (alertUsesSound() && !startAlertAudio(true)) {
        playAlertPulse();
    }
    markActivity();
}

static void stopAlert()
{
    alertRinging = false;
    alertSource = AlertSource::NONE;
    lastAlertPulseMs = 0;
    stopAlertAudio();
}

static void serviceAlert()
{
    serviceAlertAudio();
    if (!alertRinging) {
        return;
    }
    const uint32_t now = millis();
    if (alertUsesVibration() &&
        now - lastAlertPulseMs >= ALERT_REPEAT_MS) {
        lastAlertPulseMs = now;
        instance.vibrator();
    }
}

static bool alarmAllowedToday()
{
    struct tm now = {};
    instance.rtc.getDateTime(&now);
    const bool weekend = now.tm_wday == 0 || now.tm_wday == 6;
    if (clockAlarmRepeat == AlarmRepeat::WEEKDAYS) {
        return !weekend;
    }
    if (clockAlarmRepeat == AlarmRepeat::WEEKENDS) {
        return weekend;
    }
    return true;
}

static void configureClockAlarm()
{
    instance.rtc.resetAlarm();
    if (!clockAlarmEnabled) {
        instance.rtc.disableAlarm();
        return;
    }
    instance.rtc.setAlarm(
        clockAlarmHour, clockAlarmMinute, 0xFF, 0xFF);
    instance.rtc.enableAlarm();
    pinMode(RTC_INT, INPUT_PULLUP);
}

static void pollClockAlarm()
{
    if (alarmSnoozeEndsUs > 0 &&
        monotonicUs() >= alarmSnoozeEndsUs) {
        alarmSnoozeEndsUs = 0;
        startAlert(AlertSource::CLOCK);
        currentView = View::ALARM;
        buildCurrentView();
        return;
    }
    if (!clockAlarmEnabled) {
        return;
    }
    const uint32_t nowMs = millis();
    if (nowMs - lastClockAlarmPollMs < 500U) {
        return;
    }
    lastClockAlarmPollMs = nowMs;
    if (!instance.rtc.isAlarmActive()) {
        return;
    }
    instance.rtc.resetAlarm();
    const int64_t nowEpoch = readRtcEpoch();
    if (nowEpoch > 0 &&
        lastClockAlarmEpoch > 0 &&
        nowEpoch - lastClockAlarmEpoch < 60) {
        return;
    }
    lastClockAlarmEpoch = nowEpoch;
    if (!alarmAllowedToday()) {
        return;
    }
    if (clockAlarmRepeat == AlarmRepeat::ONCE) {
        clockAlarmEnabled = false;
        saveSettings();
        instance.rtc.disableAlarm();
    }
    startAlert(AlertSource::CLOCK);
    currentView = View::ALARM;
    buildCurrentView();
}

static const char *cardinalDirection(double degrees)
{
    static const char *const names[] = {
        "N", "NNE", "NE", "ENE", "E", "ESE", "SE", "SSE",
        "S", "SSW", "SW", "WSW", "W", "WNW", "NW", "NNW"
    };
    int index = static_cast<int>(floor((degrees + 11.25) / 22.5)) & 15;
    return names[index];
}

static double distanceMeters(double lat1, double lon1,
                             double lat2, double lon2)
{
    static constexpr double R = 6371000.0;
    static constexpr double D2R = 0.017453292519943295;
    const double p1 = lat1 * D2R;
    const double p2 = lat2 * D2R;
    const double dp = (lat2 - lat1) * D2R;
    const double dl = (lon2 - lon1) * D2R;
    const double a = sin(dp / 2.0) * sin(dp / 2.0) +
                     cos(p1) * cos(p2) *
                     sin(dl / 2.0) * sin(dl / 2.0);
    return R * 2.0 * atan2(sqrt(a), sqrt(1.0 - a));
}

static double initialBearing(double lat1, double lon1,
                             double lat2, double lon2)
{
    static constexpr double D2R = 0.017453292519943295;
    static constexpr double R2D = 57.29577951308232;
    const double p1 = lat1 * D2R;
    const double p2 = lat2 * D2R;
    const double dl = (lon2 - lon1) * D2R;
    const double y = sin(dl) * cos(p2);
    const double x = cos(p1) * sin(p2) -
                     sin(p1) * cos(p2) * cos(dl);
    double result = atan2(y, x) * R2D;
    if (result < 0.0) {
        result += 360.0;
    }
    return result;
}

static void shopCoordinates(size_t index, double &latitude, double &longitude)
{
    const WatchShopRecord &shop = BFWATCH_SHOPS[index];
    latitude = static_cast<double>(shop.latitudeE6) / 1000000.0;
    longitude = static_cast<double>(shop.longitudeE6) / 1000000.0;
}

static uint32_t shopIdentifierHash(size_t index)
{
    const char *text =
        bfwatchString(BFWATCH_SHOPS[index].identifierOffset);
    uint32_t hash = 2166136261UL;
    while (*text != '\0') {
        hash ^= static_cast<uint8_t>(*text++);
        hash *= 16777619UL;
    }
    return hash;
}

static uint32_t strainNameHash(const char *name)
{
    uint32_t hash = 2166136261UL;
    if (name == nullptr) {
        return hash;
    }
    while (*name != '\0' &&
           isspace(static_cast<unsigned char>(*name))) {
        ++name;
    }
    while (*name != '\0') {
        hash ^= static_cast<uint8_t>(
            tolower(static_cast<unsigned char>(*name++)));
        hash *= 16777619UL;
    }
    return hash;
}

static size_t logoSpriteBytes()
{
    return static_cast<size_t>(BFWATCH_LOGO_WIDTH) *
           BFWATCH_LOGO_HEIGHT * sizeof(lv_color32_t);
}

static bool loadMenuLogoBuffer()
{
    if (menuLogoBufferReady) {
        return true;
    }
    if (!logoPackageReady || logoIndexRecords == nullptr) {
        return false;
    }

    const size_t spriteBytes = logoSpriteBytes();
    const size_t totalBytes =
        static_cast<size_t>(BFWATCH_SHOP_COUNT) * spriteBytes;
    if (menuLogoBuffer == nullptr) {
        menuLogoBuffer = static_cast<uint8_t *>(ps_malloc(totalBytes));
    }
    if (menuLogoBuffer == nullptr) {
        return false;
    }
    memset(menuLogoBuffer, 0, totalBytes);

    File logoData = FFat.open("/logos.bin", FILE_READ);
    if (!logoData) {
        return false;
    }
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        const int32_t recordIndex = findLogoRecordIndex(
            shopIdentifierHash(index));
        if (recordIndex < 0) {
            continue;
        }
        const LogoIndexRecord &record = logoIndexRecords[recordIndex];
        uint8_t *destination =
            menuLogoBuffer + index * spriteBytes;
        if (!logoData.seek(record.offset) ||
            logoData.read(destination, spriteBytes) != spriteBytes) {
            memset(destination, 0, spriteBytes);
        }
    }
    logoData.close();
    menuLogoBufferReady = true;
    return true;
}

static uint8_t *menuLogoPixels(size_t index)
{
    if (index >= BFWATCH_SHOP_COUNT || !loadMenuLogoBuffer()) {
        return nullptr;
    }
    return menuLogoBuffer + index * logoSpriteBytes();
}

static bool isShopFavourite(size_t index)
{
    const uint32_t hash = shopIdentifierHash(index);
    for (size_t i = 0; i < favouriteShopCount; ++i) {
        if (favouriteShopHashes[i] == hash) {
            return true;
        }
    }
    return false;
}

static void saveShopPreferences()
{
    Preferences preferences;
    if (!preferences.begin("bfwatch", false)) {
        return;
    }
    preferences.putUChar("favcount",
                         static_cast<uint8_t>(favouriteShopCount));
    if (favouriteShopCount > 0) {
        preferences.putBytes("favshops", favouriteShopHashes,
                             favouriteShopCount * sizeof(uint32_t));
    } else {
        preferences.remove("favshops");
    }
    // Selection was removed in favour of a random watch-face shop.
    preferences.remove("selected");
    preferences.end();
}

static void loadShopPreferences()
{
    Preferences preferences;
    bool haveStoredFavourites = false;
    if (preferences.begin("bfwatch", false)) {
        haveStoredFavourites = preferences.isKey("favcount");
        if (haveStoredFavourites) {
            const size_t requested = preferences.getUChar("favcount", 0);
            const size_t bytes = preferences.getBytesLength("favshops");
            favouriteShopCount =
                min(requested, min(MAX_FAVOURITE_SHOPS,
                                   bytes / sizeof(uint32_t)));
            if (favouriteShopCount > 0) {
                preferences.getBytes(
                    "favshops", favouriteShopHashes,
                    favouriteShopCount * sizeof(uint32_t));
            }
        }
        // Ignore and remove selections saved by earlier firmware versions.
        preferences.remove("selected");
        preferences.end();
    }

    if (!haveStoredFavourites) {
        for (size_t i = 0;
             i < BFWATCH_SHOP_COUNT &&
             favouriteShopCount < MAX_FAVOURITE_SHOPS;
             ++i) {
            if (BFWATCH_SHOPS[i].flags & WATCH_SHOP_FAVOURITE) {
                favouriteShopHashes[favouriteShopCount++] =
                    shopIdentifierHash(i);
            }
        }
        saveShopPreferences();
    }
}

static bool isStrainFavourite(const char *name)
{
    const uint32_t hash = strainNameHash(name);
    for (size_t index = 0; index < favouriteStrainCount; ++index) {
        if (favouriteStrainHashes[index] == hash) {
            return true;
        }
    }
    return false;
}

static void saveStrainPreferences()
{
    Preferences preferences;
    if (!preferences.begin("bfwatch", false)) {
        return;
    }
    preferences.putUChar(
        "favstcount", static_cast<uint8_t>(favouriteStrainCount));
    if (favouriteStrainCount > 0) {
        preferences.putBytes(
            "favstrains", favouriteStrainHashes,
            favouriteStrainCount * sizeof(uint32_t));
    } else {
        preferences.remove("favstrains");
    }
    preferences.end();
}

static void loadStrainPreferences()
{
    Preferences preferences;
    if (!preferences.begin("bfwatch", true)) {
        return;
    }
    const size_t requested =
        preferences.getUChar("favstcount", 0);
    const size_t bytes =
        preferences.getBytesLength("favstrains");
    favouriteStrainCount =
        min(requested, min(
            MAX_FAVOURITE_STRAINS,
            bytes / sizeof(uint32_t)));
    if (favouriteStrainCount > 0) {
        preferences.getBytes(
            "favstrains", favouriteStrainHashes,
            favouriteStrainCount * sizeof(uint32_t));
    }
    preferences.end();
}

static void toggleSelectedStrainFavourite()
{
    if (selectedStrainName[0] == '\0') {
        return;
    }
    const uint32_t hash = strainNameHash(selectedStrainName);
    for (size_t index = 0; index < favouriteStrainCount; ++index) {
        if (favouriteStrainHashes[index] != hash) {
            continue;
        }
        for (size_t next = index + 1;
             next < favouriteStrainCount; ++next) {
            favouriteStrainHashes[next - 1] =
                favouriteStrainHashes[next];
        }
        --favouriteStrainCount;
        saveStrainPreferences();
        return;
    }
    if (favouriteStrainCount < MAX_FAVOURITE_STRAINS) {
        favouriteStrainHashes[favouriteStrainCount++] = hash;
        saveStrainPreferences();
    }
}

static const char *gpsUpdateModeName()
{
    switch (gpsUpdateMode) {
    case GpsUpdateMode::MANUAL:      return "MANUAL";
    case GpsUpdateMode::CONSTANT:    return "CONSTANT";
    case GpsUpdateMode::MINUTES_2_5: return "EVERY 2.5 MIN";
    case GpsUpdateMode::MINUTES_5:   return "EVERY 5 MIN";
    case GpsUpdateMode::AMSTERDAM:   return "AMSTERDAM";
    case GpsUpdateMode::COUNT:       break;
    }
    return "MANUAL";
}

static int64_t gpsUpdateIntervalUs()
{
    switch (gpsUpdateMode) {
    case GpsUpdateMode::CONSTANT:
    case GpsUpdateMode::AMSTERDAM:
        return static_cast<int64_t>(GPS_LIVE_REFRESH_MS) * 1000LL;
    case GpsUpdateMode::MINUTES_2_5:
        return 150LL * 1000000LL;
    case GpsUpdateMode::MINUTES_5:
        return 300LL * 1000000LL;
    case GpsUpdateMode::MANUAL:
    case GpsUpdateMode::COUNT:
        return 0;
    }
    return 0;
}

static bool gpsModeTracksLive()
{
    return gpsUpdateMode == GpsUpdateMode::CONSTANT ||
           gpsUpdateMode == GpsUpdateMode::AMSTERDAM;
}

static bool amsterdamGpsWarmHoldAllowed()
{
    if (gpsUpdateMode != GpsUpdateMode::AMSTERDAM ||
        !gpsAcquiring || gpsManualRequest || !haveFix ||
        !insideAmsterdam(lastLatitude, lastLongitude)) {
        return false;
    }

    const int batteryPercent = instance.pmu.getBatteryPercent();
    return instance.pmu.isVbusIn() || batteryPercent < 0 ||
           batteryPercent >= AMSTERDAM_GPS_MIN_BATTERY_PERCENT;
}

static bool automaticGpsAllowed()
{
    return gpsUpdateMode != GpsUpdateMode::MANUAL &&
           haveFix && insideAmsterdam(lastLatitude, lastLongitude);
}

static void saveSettings()
{
    Preferences preferences;
    if (!preferences.begin("bfwatch", false)) {
        return;
    }
    preferences.putUChar(
        "gpsmode", static_cast<uint8_t>(gpsUpdateMode));
    preferences.putUChar("scrntime", screenTimeoutIndex);
    preferences.putUChar("bright", screenBrightness);
    preferences.putUChar("alertmode", static_cast<uint8_t>(alertMode));
    preferences.putUChar("volume", alertVolumePercent);
    preferences.putUChar("speedunit", static_cast<uint8_t>(speedUnit));
    preferences.putUChar(
        "watchshop", static_cast<uint8_t>(watchShopMode));
    preferences.putBool("alarmon", clockAlarmEnabled);
    preferences.putUChar("alarmhour", clockAlarmHour);
    preferences.putUChar("alarmmin", clockAlarmMinute);
    preferences.putUChar(
        "alarmrep", static_cast<uint8_t>(clockAlarmRepeat));
    preferences.putUChar("workmins", intervalWorkMinutes);
    preferences.putUChar("breakmins", intervalBreakMinutes);
    preferences.putString("strain", selectedStrainName);
    preferences.end();
}

static void loadSettings()
{
    Preferences preferences;
    if (!preferences.begin("bfwatch", true)) {
        return;
    }
    const uint8_t storedGpsMode = preferences.getUChar(
        "gpsmode", static_cast<uint8_t>(GpsUpdateMode::MANUAL));
    gpsUpdateMode = storedGpsMode <
            static_cast<uint8_t>(GpsUpdateMode::COUNT)
        ? static_cast<GpsUpdateMode>(storedGpsMode)
        : GpsUpdateMode::MANUAL;
    screenTimeoutIndex = preferences.getUChar("scrntime", 0);
    if (screenTimeoutIndex >= SCREEN_TIMEOUT_OPTION_COUNT) {
        screenTimeoutIndex = 0;
    }
    screenBrightness = preferences.getUChar(
        "bright", DEFAULT_SCREEN_BRIGHTNESS);
    screenBrightness = constrain(screenBrightness, 30, 230);
    const uint8_t storedAlert = preferences.getUChar(
        "alertmode", static_cast<uint8_t>(AlertMode::BOTH));
    alertMode = storedAlert < static_cast<uint8_t>(AlertMode::COUNT)
        ? static_cast<AlertMode>(storedAlert) : AlertMode::BOTH;
    alertVolumePercent = constrain(
        preferences.getUChar("volume", 60),
        ALERT_VOLUME_STEP, static_cast<uint8_t>(100));
    alertVolumePercent =
        static_cast<uint8_t>(
            ((alertVolumePercent + ALERT_VOLUME_STEP / 2) /
             ALERT_VOLUME_STEP) * ALERT_VOLUME_STEP);
    const uint8_t storedUnit = preferences.getUChar(
        "speedunit", static_cast<uint8_t>(SpeedUnit::KPH));
    speedUnit = storedUnit < static_cast<uint8_t>(SpeedUnit::COUNT)
        ? static_cast<SpeedUnit>(storedUnit) : SpeedUnit::KPH;
    const uint8_t storedWatchShop = preferences.getUChar(
        "watchshop", static_cast<uint8_t>(WatchShopMode::RANDOM));
    watchShopMode =
        storedWatchShop < static_cast<uint8_t>(WatchShopMode::COUNT)
            ? static_cast<WatchShopMode>(storedWatchShop)
            : WatchShopMode::RANDOM;
    clockAlarmEnabled = preferences.getBool("alarmon", false);
    clockAlarmHour = min(
        preferences.getUChar("alarmhour", 8),
        static_cast<uint8_t>(23));
    clockAlarmMinute = min(
        preferences.getUChar("alarmmin", 0),
        static_cast<uint8_t>(59));
    const uint8_t storedRepeat = preferences.getUChar(
        "alarmrep", static_cast<uint8_t>(AlarmRepeat::DAILY));
    clockAlarmRepeat =
        storedRepeat < static_cast<uint8_t>(AlarmRepeat::COUNT)
            ? static_cast<AlarmRepeat>(storedRepeat)
            : AlarmRepeat::DAILY;
    intervalWorkMinutes = constrain(
        preferences.getUChar("workmins", 25), 1, 90);
    intervalBreakMinutes = constrain(
        preferences.getUChar("breakmins", 5), 1, 30);
    intervalRemainingUs =
        static_cast<uint64_t>(intervalWorkMinutes) *
        60ULL * 1000000ULL;
    const String storedStrain = preferences.getString("strain", "");
    storedStrain.toCharArray(
        selectedStrainName, sizeof(selectedStrainName));
    preferences.end();
}

static void configureRaiseToWakeSensor()
{
    motionSensorReady =
        (instance.getDeviceProbe() & HW_BMA423_ONLINE) != 0;
    if (!motionSensorReady) {
        return;
    }

    instance.sensor.disablePedometerIRQ();
    instance.sensor.disableActivityIRQ();
    instance.sensor.disableAnyNoMotionIRQ();
    instance.sensor.disableWakeupIRQ();
    instance.sensor.disableTiltIRQ();
    instance.sensor.enableFeature(
        SensorBMA423::FEATURE_ANY_MOTION |
        SensorBMA423::FEATURE_NO_MOTION |
        SensorBMA423::FEATURE_ACTIVITY |
        SensorBMA423::FEATURE_TILT |
        SensorBMA423::FEATURE_WAKEUP,
        false);

    // Keep the hardware pedometer active independently of raise-to-wake.
    instance.sensor.configAccelerometer();
    instance.sensor.enableAccelerometer();
    instance.sensor.enablePedometer();

    if (raiseToWakeEnabled) {
        // Level-triggered, active-low, push-pull INT1. Matching the polarity
        // of touch and PMU lets all wake sources share one EXT1 ANY_LOW group.
        instance.sensor.configInterrupt(0, 0);
        instance.sensor.enableFeature(
            SensorBMA423::FEATURE_TILT, true);
        instance.sensor.enableTiltIRQ();
        pinMode(SENSOR_INT, INPUT_PULLUP);
    }
    instance.sensor.readIrqStatus();
}

static void toggleShopFavourite(size_t index)
{
    const uint32_t hash = shopIdentifierHash(index);
    for (size_t i = 0; i < favouriteShopCount; ++i) {
        if (favouriteShopHashes[i] != hash) {
            continue;
        }
        for (size_t j = i + 1; j < favouriteShopCount; ++j) {
            favouriteShopHashes[j - 1] = favouriteShopHashes[j];
        }
        --favouriteShopCount;
        if (watchShopMode == WatchShopMode::FAVOURITES) {
            rotatingWatchShopIndex = -1;
            rotatingWatchShopChangedMs = 0;
        }
        saveShopPreferences();
        return;
    }
    if (favouriteShopCount < MAX_FAVOURITE_SHOPS) {
        favouriteShopHashes[favouriteShopCount++] = hash;
        if (watchShopMode == WatchShopMode::FAVOURITES) {
            rotatingWatchShopIndex = -1;
            rotatingWatchShopChangedMs = 0;
        }
        saveShopPreferences();
    }
}

static double distanceToShop(size_t index)
{
    double latitude = 0.0;
    double longitude = 0.0;
    shopCoordinates(index, latitude, longitude);
    return distanceMeters(lastLatitude, lastLongitude, latitude, longitude);
}

static double bearingToShop(size_t index)
{
    double latitude = 0.0;
    double longitude = 0.0;
    shopCoordinates(index, latitude, longitude);
    return initialBearing(lastLatitude, lastLongitude, latitude, longitude);
}

static bool shopComesBefore(size_t left, size_t right)
{
    const bool leftFavourite = isShopFavourite(left);
    const bool rightFavourite = isShopFavourite(right);
    if (leftFavourite != rightFavourite) {
        return leftFavourite;
    }

    if (haveFix && insideAmsterdam(lastLatitude, lastLongitude)) {
        const double leftDistance = distanceToShop(left);
        const double rightDistance = distanceToShop(right);
        if (fabs(leftDistance - rightDistance) > 0.1) {
            return leftDistance < rightDistance;
        }
    }

    return strcasecmp(
        bfwatchString(BFWATCH_SHOPS[left].nameOffset),
        bfwatchString(BFWATCH_SHOPS[right].nameOffset)) < 0;
}

static void rebuildShopDisplayOrder()
{
    for (size_t i = 0; i < BFWATCH_SHOP_COUNT; ++i) {
        shopDisplayOrder[i] = static_cast<uint16_t>(i);
    }
    for (size_t i = 1; i < BFWATCH_SHOP_COUNT; ++i) {
        const uint16_t value = shopDisplayOrder[i];
        size_t position = i;
        while (position > 0 &&
               shopComesBefore(value, shopDisplayOrder[position - 1])) {
            shopDisplayOrder[position] = shopDisplayOrder[position - 1];
            --position;
        }
        shopDisplayOrder[position] = value;
    }
}

static void calculateNearest()
{
    haveNearest = false;
    nearestName = nullptr;
    nearestShopIndex = -1;

    if (!haveFix) {
        return;
    }

    for (size_t i = 0; i < BFWATCH_SHOP_COUNT; ++i) {
        const WatchShopRecord &shop = BFWATCH_SHOPS[i];
        const double shopLatitude =
            static_cast<double>(shop.latitudeE6) / 1000000.0;
        const double shopLongitude =
            static_cast<double>(shop.longitudeE6) / 1000000.0;
        const double distance = distanceMeters(
            lastLatitude, lastLongitude,
            shopLatitude, shopLongitude);

        if (!haveNearest || distance < nearestDistanceM) {
            haveNearest = true;
            nearestShopIndex = static_cast<int16_t>(i);
            nearestName = bfwatchString(shop.nameOffset);
            nearestDistanceM = distance;
            nearestBearingDeg = initialBearing(
                lastLatitude, lastLongitude,
                shopLatitude, shopLongitude);
        }
    }
}

static void saveFix()
{
    CachedFix fix = {
        FIX_VERSION,
        lastLatitude,
        lastLongitude,
        lastFixEpoch
    };
    Preferences preferences;
    if (preferences.begin("bfwatch", false)) {
        preferences.putBytes("lastfix", &fix, sizeof(fix));
        preferences.end();
    }
}

static void loadFix()
{
    CachedFix fix = {};
    Preferences preferences;
    if (!preferences.begin("bfwatch", true)) {
        return;
    }
    if (preferences.getBytesLength("lastfix") == sizeof(fix)) {
        preferences.getBytes("lastfix", &fix, sizeof(fix));
    }
    preferences.end();

    if (fix.version == FIX_VERSION &&
        isfinite(fix.latitude) && isfinite(fix.longitude) &&
        fix.latitude >= -90.0 && fix.latitude <= 90.0 &&
        fix.longitude >= -180.0 && fix.longitude <= 180.0) {
        haveFix = true;
        lastLatitude = fix.latitude;
        lastLongitude = fix.longitude;
        lastFixEpoch = fix.rtcEpoch;
        calculateNearest();
    }
}

// -----------------------------------------------------------------------------
// LVGL helpers
// -----------------------------------------------------------------------------

static void setLabel(lv_obj_t *label, const char *text)
{
    if (label != nullptr) {
        lv_label_set_text(label, text);
    }
}

static lv_obj_t *makeLabel(lv_obj_t *parent, int16_t y, int16_t width,
                           lv_text_align_t alignment = LV_TEXT_ALIGN_CENTER)
{
    lv_obj_t *label = lv_label_create(parent);
    lv_obj_set_width(label, width);
    const int16_t parentWidth = lv_obj_get_content_width(parent);
    lv_obj_set_pos(
        label,
        max(0, (static_cast<int>(parentWidth) - width) / 2),
        y);
    lv_obj_set_style_text_align(label, alignment, 0);
    lv_obj_set_style_text_color(label, lv_color_hex(THEME_TEXT), 0);
    lv_label_set_long_mode(label, LV_LABEL_LONG_WRAP);
    return label;
}

static void containLabel(lv_obj_t *label, int16_t height,
                         lv_label_long_mode_t longMode = LV_LABEL_LONG_DOT)
{
    if (label == nullptr) {
        return;
    }
    lv_obj_set_height(label, height);
    lv_label_set_long_mode(label, longMode);
    lv_obj_clear_flag(label, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_clear_flag(label, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(label, LV_OBJ_FLAG_SCROLLABLE);
}

static void updateBatteryBadge()
{
    if (batteryLabel == nullptr) {
        return;
    }
    const int percent = instance.pmu.getBatteryPercent();
    char text[16];
    if (percent < 0 || percent > 100) {
        snprintf(text, sizeof(text), "--%%");
    } else {
        snprintf(
            text, sizeof(text), "%d%%%s",
            percent, instance.pmu.isVbusIn() ? "+" : "");
    }
    lv_label_set_text(batteryLabel, text);
}

static lv_obj_t *makeBatteryBadge(lv_obj_t *parent)
{
    lv_obj_t *badge = lv_obj_create(parent);
    lv_obj_set_pos(
        badge, STATUS_BATTERY_X, STATUS_BATTERY_Y);
    lv_obj_set_size(
        badge, STATUS_BATTERY_WIDTH, STATUS_BATTERY_HEIGHT);
    lv_obj_set_style_radius(badge, 12, 0);
    lv_obj_set_style_bg_color(
        badge, lv_color_hex(THEME_BACKGROUND), 0);
    lv_obj_set_style_bg_opa(badge, LV_OPA_80, 0);
    lv_obj_set_style_border_color(
        badge, lv_color_hex(THEME_BORDER), 0);
    lv_obj_set_style_border_width(badge, 1, 0);
    lv_obj_set_style_pad_all(badge, 0, 0);
    lv_obj_clear_flag(badge, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(badge, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_clear_flag(badge, LV_OBJ_FLAG_OVERFLOW_VISIBLE);

    batteryLabel = lv_label_create(badge);
    lv_obj_set_pos(batteryLabel, 2, 4);
    lv_obj_set_size(
        batteryLabel, STATUS_BATTERY_WIDTH - 4, 16);
    lv_label_set_long_mode(batteryLabel, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_align(
        batteryLabel, LV_TEXT_ALIGN_CENTER, 0);
    lv_obj_set_style_text_font(
        batteryLabel, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(
        batteryLabel, lv_color_hex(THEME_GOLD), 0);
    lv_obj_clear_flag(batteryLabel, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(batteryLabel, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_clear_flag(batteryLabel, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    updateBatteryBadge();
    return batteryLabel;
}

static void runningAppSymbols(char *buffer, size_t bufferSize)
{
    buffer[0] = '\0';
    const auto append = [&](const char *symbol) {
        strlcat(buffer, symbol, bufferSize);
    };
    if (stopwatchRunning) {
        append(LV_SYMBOL_PLAY);
    }
    if (timerRunning || clockAlarmEnabled || alertRinging) {
        append(LV_SYMBOL_BELL);
    }
    if (intervalRunning) {
        append(LV_SYMBOL_LOOP);
    }
    if (speedometerRunning || gpsAcquiring) {
        append(LV_SYMBOL_GPS);
    }
    if (jokeApActive) {
        append(LV_SYMBOL_WIFI);
    }
    if (alertAudioPlaying) {
        append(LV_SYMBOL_AUDIO);
    }
}

static void updateRunningAppsLabel()
{
    if (runningAppsLabel == nullptr) {
        return;
    }
    char symbols[80];
    runningAppSymbols(symbols, sizeof(symbols));
    lv_label_set_text(runningAppsLabel, symbols);
}

static lv_obj_t *makeRunningAppsLabel(
    lv_obj_t *parent, int16_t x, int16_t y, int16_t width)
{
    runningAppsLabel = lv_label_create(parent);
    lv_obj_set_pos(runningAppsLabel, x, y);
    lv_obj_set_size(runningAppsLabel, width, 16);
    lv_label_set_long_mode(
        runningAppsLabel, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_align(
        runningAppsLabel, LV_TEXT_ALIGN_CENTER, 0);
    lv_obj_set_style_text_font(
        runningAppsLabel, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(
        runningAppsLabel, lv_color_hex(THEME_GOLD), 0);
    lv_obj_clear_flag(runningAppsLabel, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(runningAppsLabel, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_clear_flag(runningAppsLabel, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    updateRunningAppsLabel();
    return runningAppsLabel;
}

static bool viewHasRunningState(View view)
{
    switch (view) {
    case View::STOPWATCH: return stopwatchRunning;
    case View::TIMER: return timerRunning ||
        (alertRinging && alertSource == AlertSource::COUNTDOWN);
    case View::ALARM: return clockAlarmEnabled ||
        (alertRinging && alertSource == AlertSource::CLOCK);
    case View::INTERVAL: return intervalRunning;
    case View::SPEEDOMETER: return speedometerRunning;
    case View::WIFI_AP: return jokeApActive;
    case View::GPS: return gpsAcquiring;
    default: return false;
    }
}

static lv_obj_t *makeTopTitle(const char *text,
                              int16_t left = 78, int16_t right = 56)
{
    const int16_t width = max(
        1, 240 - static_cast<int>(left) - static_cast<int>(right));
    lv_obj_t *title = makeLabel(lv_scr_act(), 10, width);
    lv_obj_set_pos(title, left, 10);
    containLabel(title, 22);
    lv_obj_set_style_text_font(
        title,
        (strlen(text) > 12) ? &lv_font_montserrat_12
                            : &lv_font_montserrat_14,
        0);
    lv_obj_set_style_text_color(
        title, lv_color_hex(THEME_ACCENT), 0);
    lv_label_set_text(title, text);
    makeBatteryBadge(lv_scr_act());
    return title;
}

static void buttonEvent(lv_event_t *event);

static lv_obj_t *makeButton(lv_obj_t *parent, const char *text,
                            int16_t x, int16_t y, int16_t width, int16_t height,
                            intptr_t action)
{
    lv_obj_t *button = lv_btn_create(parent);
    lv_obj_set_pos(button, x, y);
    lv_obj_set_size(button, width, height);
    lv_obj_set_style_radius(button, 12, 0);
    lv_obj_set_style_bg_color(button, lv_color_hex(THEME_BUTTON), 0);
    lv_obj_set_style_bg_color(
        button, lv_color_hex(THEME_BUTTON_PRESSED), LV_STATE_PRESSED);
    lv_obj_set_style_border_color(
        button, lv_color_hex(THEME_BORDER), 0);
    lv_obj_set_style_border_width(button, 1, 0);
    lv_obj_set_style_shadow_color(button, lv_color_hex(0x000000), 0);
    lv_obj_set_style_shadow_opa(button, LV_OPA_30, 0);
    lv_obj_set_style_shadow_width(button, 5, 0);
    lv_obj_set_style_shadow_offset_y(button, 2, 0);
    lv_obj_set_style_pad_all(button, 2, 0);
    lv_obj_clear_flag(button, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_add_flag(button, LV_OBJ_FLAG_GESTURE_BUBBLE);
    lv_obj_set_ext_click_area(button, 2);
    lv_obj_add_event_cb(button, buttonEvent, LV_EVENT_CLICKED,
                        reinterpret_cast<void *>(action));

    lv_obj_t *label = lv_label_create(button);
    lv_label_set_text(label, text);
    lv_obj_set_size(
        label,
        max(1, static_cast<int>(width) - 10),
        min(22, max(1, static_cast<int>(height) - 6)));
    lv_label_set_long_mode(label, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_align(label, LV_TEXT_ALIGN_CENTER, 0);
    lv_obj_set_style_text_color(label, lv_color_hex(THEME_TEXT), 0);
    const size_t labelLength = strlen(text);
    const int16_t estimatedTextWidth =
        static_cast<int16_t>(labelLength * 8U);
    lv_obj_set_style_text_font(
        label,
        estimatedTextWidth >= width - 12
            ? &lv_font_montserrat_12
            : &lv_font_montserrat_14,
        0);
    lv_obj_clear_flag(label, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_clear_flag(label, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(label, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_center(label);
    return button;
}

static lv_obj_t *makeListButton(
    lv_obj_t *parent, const char *text, int16_t y, intptr_t action)
{
    lv_obj_t *button = makeButton(parent, text, 3, y, 220, 42, action);
    lv_obj_set_style_shadow_width(button, 0, 0);
    lv_obj_set_style_bg_color(
        button, lv_color_hex(THEME_PANEL_RAISED), 0);
    lv_obj_t *label = lv_obj_get_child(button, 0);
    if (label != nullptr) {
        lv_obj_set_width(label, 196);
        const bool multiline = strchr(text, '\n') != nullptr;
        lv_obj_set_height(label, multiline ? 34 : 20);
        lv_label_set_long_mode(
            label, multiline ? LV_LABEL_LONG_WRAP : LV_LABEL_LONG_DOT);
        lv_obj_set_style_text_font(
            label,
            multiline ? &lv_font_montserrat_12
                      : &lv_font_montserrat_14,
            0);
        lv_obj_set_style_text_align(label, LV_TEXT_ALIGN_LEFT, 0);
        lv_obj_align(label, LV_ALIGN_LEFT_MID, 10, 0);
    }
    return button;
}

static lv_obj_t *makeAppMenuRow(
    lv_obj_t *parent, const char *text, int16_t y, intptr_t action)
{
    lv_obj_t *button = makeListButton(parent, text, y, action);
    lv_obj_set_style_bg_opa(button, LV_OPA_80, 0);
    lv_obj_t *label = lv_obj_get_child(button, 0);
    if (label != nullptr) {
        lv_obj_set_width(label, 204);
        lv_obj_set_style_text_align(label, LV_TEXT_ALIGN_CENTER, 0);
        lv_obj_center(label);
        const View view = static_cast<View>(action);
        if (viewHasRunningState(view)) {
            lv_obj_set_style_text_color(
                label, lv_color_hex(THEME_GOLD), 0);
            lv_obj_set_style_border_color(
                button, lv_color_hex(THEME_ACCENT), 0);
            lv_obj_set_style_border_width(button, 2, 0);
        }
    }
    return button;
}

static bool addMenuRowLogo(lv_obj_t *button, size_t shopIndex)
{
    uint8_t *pixels = menuLogoPixels(shopIndex);
    if (button == nullptr || pixels == nullptr) {
        return false;
    }
    lv_obj_t *canvas = lv_canvas_create(button);
    lv_canvas_set_buffer(
        canvas, pixels,
        BFWATCH_LOGO_WIDTH, BFWATCH_LOGO_HEIGHT,
        LV_COLOR_FORMAT_ARGB8888);
    lv_image_set_scale(
        canvas,
        static_cast<uint16_t>(
            256U * COMPACT_LOGO_SIZE / BFWATCH_LOGO_WIDTH));
    lv_image_set_antialias(canvas, true);
    lv_obj_set_pos(
        canvas,
        9 + static_cast<int16_t>(COMPACT_LOGO_SIZE) / 2 -
            static_cast<int16_t>(BFWATCH_LOGO_WIDTH) / 2,
        7 + static_cast<int16_t>(COMPACT_LOGO_SIZE) / 2 -
            static_cast<int16_t>(BFWATCH_LOGO_HEIGHT) / 2);
    lv_obj_clear_flag(canvas, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(canvas, LV_OBJ_FLAG_SCROLLABLE);

    lv_obj_t *label = lv_obj_get_child(button, 0);
    if (label != nullptr) {
        lv_obj_set_width(label, 170);
        lv_obj_set_height(label, 34);
        lv_label_set_long_mode(label, LV_LABEL_LONG_WRAP);
        lv_obj_set_style_text_font(
            label, &lv_font_montserrat_12, 0);
        lv_obj_align(label, LV_ALIGN_LEFT_MID, 41, 0);
    }
    return true;
}

static bool addShopHeaderLogo(size_t shopIndex)
{
    uint8_t *pixels = menuLogoPixels(shopIndex);
    if (pixels == nullptr) {
        return false;
    }

    lv_obj_t *frame = lv_obj_create(lv_scr_act());
    lv_obj_set_pos(frame, 7, 46);
    lv_obj_set_size(frame, 42, 42);
    lv_obj_set_style_radius(frame, 10, 0);
    lv_obj_set_style_bg_color(
        frame, lv_color_hex(THEME_PANEL_RAISED), 0);
    lv_obj_set_style_bg_opa(frame, LV_OPA_COVER, 0);
    lv_obj_set_style_border_color(
        frame, lv_color_hex(THEME_ACCENT), 0);
    lv_obj_set_style_border_width(frame, 1, 0);
    lv_obj_set_style_pad_all(frame, 0, 0);
    lv_obj_clear_flag(frame, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_clear_flag(frame, LV_OBJ_FLAG_OVERFLOW_VISIBLE);

    lv_obj_t *canvas = lv_canvas_create(frame);
    lv_canvas_set_buffer(
        canvas, pixels,
        BFWATCH_LOGO_WIDTH, BFWATCH_LOGO_HEIGHT,
        LV_COLOR_FORMAT_ARGB8888);
    lv_image_set_scale(
        canvas,
        static_cast<uint16_t>(
            256U * 38U / BFWATCH_LOGO_WIDTH));
    lv_image_set_antialias(canvas, true);
    lv_obj_center(canvas);
    lv_obj_clear_flag(canvas, LV_OBJ_FLAG_CLICKABLE);
    return true;
}

static void listScrollEvent(lv_event_t *event)
{
    const lv_event_code_t code = lv_event_get_code(event);
    if (code != LV_EVENT_SCROLL_BEGIN &&
        code != LV_EVENT_SCROLL &&
        code != LV_EVENT_SCROLL_END) {
        return;
    }
    int32_t *savedOffset = static_cast<int32_t *>(
        lv_event_get_user_data(event));
    lv_obj_t *frame = static_cast<lv_obj_t *>(
        lv_event_get_current_target(event));
    if (savedOffset != nullptr && frame != nullptr) {
        *savedOffset = max(0L, lv_obj_get_scroll_y(frame));
    }
    markActivity();
}

static void captureActiveListPosition()
{
    if (activeListFrame == nullptr ||
        activeListSavedOffset == nullptr) {
        return;
    }
    *activeListSavedOffset =
        max(0L, lv_obj_get_scroll_y(activeListFrame));
}

static void finishActiveListLayout()
{
    if (activeListFrame == nullptr) {
        return;
    }

    // The content is populated after makeVerticalList() returns. Restoring
    // before those children exist lets LVGL clamp the offset back to zero,
    // which is why returning from Torch reopened BUD//APPS at the top.
    lv_obj_update_layout(lv_scr_act());
    lv_obj_scroll_to_y(
        activeListFrame, activeListRestoreOffset, LV_ANIM_OFF);
    lv_obj_add_event_cb(
        activeListFrame, listScrollEvent, LV_EVENT_ALL,
        activeListSavedOffset);
    if (activeListSavedOffset != nullptr) {
        *activeListSavedOffset =
            max(0L, lv_obj_get_scroll_y(activeListFrame));
    }
}

static lv_obj_t *makeVerticalList(
    int16_t x, int16_t y, int16_t width, int16_t height,
    int32_t contentHeight, int32_t *savedOffset)
{
    lv_obj_t *frame = lv_obj_create(lv_scr_act());
    lv_obj_set_pos(frame, x, y);
    lv_obj_set_size(frame, width, height);
    lv_obj_set_style_radius(frame, 13, 0);
    lv_obj_set_style_bg_color(frame, lv_color_hex(THEME_PANEL), 0);
    lv_obj_set_style_bg_opa(frame, LV_OPA_COVER, 0);
    lv_obj_set_style_border_color(frame, lv_color_hex(THEME_BORDER), 0);
    lv_obj_set_style_border_width(frame, 1, 0);
    lv_obj_set_style_pad_all(frame, 0, 0);
    lv_obj_clear_flag(frame, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_add_flag(frame, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_add_flag(frame, LV_OBJ_FLAG_SCROLL_MOMENTUM);
    lv_obj_add_flag(frame, LV_OBJ_FLAG_GESTURE_BUBBLE);
    lv_obj_remove_flag(frame, LV_OBJ_FLAG_SCROLL_ELASTIC);
    lv_obj_remove_flag(frame, LV_OBJ_FLAG_SCROLL_CHAIN_HOR);
    lv_obj_remove_flag(frame, LV_OBJ_FLAG_SCROLL_CHAIN_VER);
    lv_obj_set_scroll_dir(frame, LV_DIR_VER);
    lv_obj_set_scrollbar_mode(frame, LV_SCROLLBAR_MODE_OFF);

    const int16_t contentWidth = width - 2;
    const int32_t actualContentHeight =
        max(static_cast<int32_t>(height - 2), contentHeight);
    lv_obj_t *content = lv_obj_create(frame);
    lv_obj_remove_style_all(content);
    lv_obj_set_pos(content, 0, 0);
    lv_obj_set_size(
        content, contentWidth, actualContentHeight);
    lv_obj_clear_flag(content, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_clear_flag(content, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_add_flag(content, LV_OBJ_FLAG_GESTURE_BUBBLE);

    const int32_t maximumOffset =
        max(0L, actualContentHeight - static_cast<int32_t>(height - 2));
    const int32_t restoredOffset = savedOffset == nullptr
        ? 0
        : constrain(*savedOffset, 0L, maximumOffset);
    if (savedOffset != nullptr) {
        *savedOffset = restoredOffset;
    }
    activeListFrame = frame;
    activeListSavedOffset = savedOffset;
    activeListRestoreOffset = restoredOffset;
    return content;
}

static void prepareScreen()
{
    // Capture the final native-scroll position before LVGL destroys the
    // current screen. This also catches navigation during scroll momentum,
    // when a final LV_EVENT_SCROLL_END may not have fired yet.
    captureActiveListPosition();
    lv_obj_t *screen = lv_scr_act();
    lv_obj_clean(screen);
    activeListFrame = nullptr;
    activeListSavedOffset = nullptr;
    activeListRestoreOffset = 0;
    lv_obj_set_style_bg_color(screen, lv_color_hex(THEME_BACKGROUND), 0);
    lv_obj_set_style_bg_opa(screen, LV_OPA_COVER, 0);
    lv_obj_set_style_border_width(screen, 0, 0);
    lv_obj_clear_flag(screen, LV_OBJ_FLAG_SCROLLABLE);
    if (!screenGestureInstalled) {
        lv_obj_add_event_cb(screen, gestureEvent, LV_EVENT_GESTURE, nullptr);
        screenGestureInstalled = true;
    }

    if (currentView != View::MAP && currentView != View::TORCH) {
        lv_obj_t *background = lv_image_create(screen);
        lv_image_set_src(background, &BFWATCH_WATCHFACE_BACKGROUND);
        lv_obj_set_pos(background, 0, 0);
        lv_obj_clear_flag(background, LV_OBJ_FLAG_CLICKABLE);
        lv_obj_clear_flag(background, LV_OBJ_FLAG_SCROLLABLE);
    }

    primaryLabel = nullptr;
    secondaryLabel = nullptr;
    tertiaryLabel = nullptr;
    shopDistanceLabel = nullptr;
    batteryLabel = nullptr;
    runningAppsLabel = nullptr;
    audioTestButtonLabel = nullptr;
    statusLabel = nullptr;
}

static void makeMenuButton()
{
    makeButton(
        lv_scr_act(), "Apps", 6, 5, 66, 36, ACTION_OPEN_APPS);
}

static lv_obj_t *makePanel(int16_t x, int16_t y, int16_t width, int16_t height)
{
    lv_obj_t *panel = lv_obj_create(lv_scr_act());
    lv_obj_set_pos(panel, x, y);
    lv_obj_set_size(panel, width, height);
    lv_obj_set_style_radius(panel, 16, 0);
    lv_obj_set_style_bg_color(panel, lv_color_hex(THEME_PANEL), 0);
    lv_obj_set_style_bg_opa(panel, LV_OPA_COVER, 0);
    lv_obj_set_style_border_color(panel, lv_color_hex(THEME_BORDER), 0);
    lv_obj_set_style_border_width(panel, 1, 0);
    lv_obj_set_style_pad_all(panel, 0, 0);
    lv_obj_clear_flag(panel, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_clear_flag(panel, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_add_flag(panel, LV_OBJ_FLAG_GESTURE_BUBBLE);
    return panel;
}

static lv_obj_t *makeReadoutPanel(int16_t y, int16_t height)
{
    lv_obj_t *panel = makePanel(6, y, 228, height);
    lv_obj_set_style_bg_opa(panel, LV_OPA_50, 0);
    lv_obj_set_style_border_color(
        panel, lv_color_hex(THEME_BORDER), 0);
    return panel;
}

static bool rotateWatchFaceShop(bool force)
{
    if (BFWATCH_SHOP_COUNT == 0) {
        rotatingWatchShopIndex = -1;
        rotatingWatchShopChangedMs = 0;
        return false;
    }

    const uint32_t now = millis();
    if (watchShopMode == WatchShopMode::NEAREST && haveNearest) {
        const bool changed =
            rotatingWatchShopIndex != nearestShopIndex;
        rotatingWatchShopIndex = nearestShopIndex;
        rotatingWatchShopChangedMs = now;
        return changed;
    }

    if (!force && rotatingWatchShopIndex >= 0 &&
        now - rotatingWatchShopChangedMs <
            RANDOM_WATCH_SHOP_INTERVAL_MS) {
        return false;
    }

    size_t favouriteCount = 0;
    if (watchShopMode == WatchShopMode::FAVOURITES) {
        for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
            if (isShopFavourite(index)) {
                ++favouriteCount;
            }
        }
    }
    const bool useFavouritePool =
        watchShopMode == WatchShopMode::FAVOURITES &&
        favouriteCount > 0;
    const size_t eligibleCount =
        useFavouritePool ? favouriteCount : BFWATCH_SHOP_COUNT;

    size_t wanted = esp_random() % eligibleCount;
    int16_t next = -1;
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        if (useFavouritePool && !isShopFavourite(index)) {
            continue;
        }
        if (wanted-- == 0) {
            next = static_cast<int16_t>(index);
            break;
        }
    }
    if (next < 0) {
        next = static_cast<int16_t>(
            esp_random() % BFWATCH_SHOP_COUNT);
    }

    if (eligibleCount > 1 && next == rotatingWatchShopIndex) {
        for (size_t offset = 1; offset < BFWATCH_SHOP_COUNT; ++offset) {
            const size_t candidate =
                (static_cast<size_t>(next) + offset) %
                BFWATCH_SHOP_COUNT;
            if (!useFavouritePool || isShopFavourite(candidate)) {
                next = static_cast<int16_t>(candidate);
                break;
            }
        }
    }
    const bool changed = next != rotatingWatchShopIndex;
    rotatingWatchShopIndex = next;
    rotatingWatchShopChangedMs = now;
    return changed;
}

static int16_t watchFaceShopIndex()
{
    return rotatingWatchShopIndex;
}

static bool addShopLogoToWatchFace(int16_t shopIndex)
{
    if (shopIndex < 0 ||
        shopIndex >= static_cast<int16_t>(BFWATCH_SHOP_COUNT) ||
        !logoPackageReady) {
        return false;
    }
    const int32_t recordIndex = findLogoRecordIndex(
        shopIdentifierHash(static_cast<size_t>(shopIndex)));
    if (recordIndex < 0) {
        return false;
    }

    const size_t spriteBytes =
        static_cast<size_t>(BFWATCH_LOGO_WIDTH) *
        BFWATCH_LOGO_HEIGHT * sizeof(lv_color32_t);
    if (mapLogoSpriteBuffer == nullptr) {
        mapLogoSpriteBuffer =
            static_cast<uint8_t *>(ps_malloc(spriteBytes));
    }
    if (mapLogoSpriteBuffer == nullptr) {
        return false;
    }

    File logoData = FFat.open("/logos.bin", FILE_READ);
    const LogoIndexRecord &record = logoIndexRecords[recordIndex];
    const bool loaded =
        logoData && logoData.seek(record.offset) &&
        logoData.read(mapLogoSpriteBuffer, spriteBytes) == spriteBytes;
    logoData.close();
    if (!loaded) {
        return false;
    }

    lv_obj_t *canvas = lv_canvas_create(lv_scr_act());
    lv_canvas_set_buffer(
        canvas, mapLogoSpriteBuffer,
        BFWATCH_LOGO_WIDTH, BFWATCH_LOGO_HEIGHT,
        LV_COLOR_FORMAT_ARGB8888);
    lv_obj_set_pos(
        canvas,
        16 + (48 - static_cast<int16_t>(BFWATCH_LOGO_WIDTH)) / 2,
        159 + (48 - static_cast<int16_t>(BFWATCH_LOGO_HEIGHT)) / 2);
    lv_obj_clear_flag(canvas, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(canvas, LV_OBJ_FLAG_SCROLLABLE);
    return true;
}

static void buildWatchView()
{
    prepareScreen();
    rotateWatchFaceShop(false);

    lv_obj_t *brand = makeLabel(lv_scr_act(), 7, 98, LV_TEXT_ALIGN_LEFT);
    lv_obj_set_pos(brand, 8, 7);
    containLabel(brand, 20);
    lv_label_set_text(brand, "BUD//WATCH");
    lv_obj_set_style_text_font(brand, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(brand, lv_color_hex(THEME_ACCENT), 0);
    lv_obj_set_style_text_letter_space(brand, 0, 0);

    makeBatteryBadge(lv_scr_act());

    primaryLabel = makeLabel(lv_scr_act(), 18, 224);
    containLabel(primaryLabel, 58);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_48, 0);
    lv_obj_set_style_text_color(primaryLabel, lv_color_hex(THEME_GOLD), 0);
    lv_obj_set_style_text_letter_space(primaryLabel, 2, 0);

    secondaryLabel = makeLabel(lv_scr_act(), 95, 210);
    containLabel(secondaryLabel, 22);
    lv_obj_set_style_text_color(
        secondaryLabel, lv_color_hex(THEME_ACCENT), 0);

    makeRunningAppsLabel(lv_scr_act(), 108, 9, 76);

    const bool haveWatchLogo =
        addShopLogoToWatchFace(watchFaceShopIndex());

    tertiaryLabel = makeLabel(
        lv_scr_act(), 174, haveWatchLogo ? 103 : 158,
        LV_TEXT_ALIGN_LEFT);
    lv_obj_set_x(tertiaryLabel, haveWatchLogo ? 72 : 16);
    lv_obj_set_height(tertiaryLabel, 18);
    lv_label_set_long_mode(
        tertiaryLabel, LV_LABEL_LONG_SCROLL_CIRCULAR);
    lv_obj_set_style_text_font(
        tertiaryLabel, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(tertiaryLabel, lv_color_hex(THEME_TEXT), 0);

    shopDistanceLabel = makeLabel(
        lv_scr_act(), 174, 49, LV_TEXT_ALIGN_RIGHT);
    lv_obj_set_x(shopDistanceLabel, 178);
    lv_obj_set_height(shopDistanceLabel, 18);
    lv_label_set_long_mode(shopDistanceLabel, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_font(
        shopDistanceLabel, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(
        shopDistanceLabel, lv_color_hex(THEME_GOLD), 0);

    lv_obj_t *hint = makeLabel(lv_scr_act(), 214, 220);
    containLabel(hint, 18);
    lv_label_set_text(hint, "SWIPE LEFT  //  APPS");
    lv_obj_set_style_text_color(hint, lv_color_hex(THEME_SUBTLE), 0);
    lv_obj_set_style_text_font(hint, &lv_font_montserrat_12, 0);

    if (watchFaceShopIndex() >= 0) {
        lv_obj_t *mapTarget = makeButton(
            lv_scr_act(), "", 8, 150, 224, 60, 703);
        lv_obj_set_style_bg_opa(mapTarget, LV_OPA_TRANSP, 0);
        lv_obj_set_style_bg_opa(mapTarget, LV_OPA_20, LV_STATE_PRESSED);
        lv_obj_set_style_border_width(mapTarget, 0, 0);
        lv_obj_set_style_shadow_width(mapTarget, 0, 0);
    }
}

static void buildMenuView()
{
    prepareScreen();

    lv_obj_t *title = lv_label_create(lv_scr_act());
    lv_obj_set_pos(title, 10, 7);
    lv_obj_set_size(title, 88, 20);
    lv_label_set_long_mode(title, LV_LABEL_LONG_DOT);
    lv_label_set_text(title, "BUD//APPS");
    lv_obj_set_style_text_font(title, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(title, lv_color_hex(THEME_ACCENT), 0);
    lv_obj_set_style_text_align(title, LV_TEXT_ALIGN_LEFT, 0);
    lv_obj_set_style_text_letter_space(title, 1, 0);
    lv_obj_clear_flag(title, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_clear_flag(title, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(title, LV_OBJ_FLAG_SCROLLABLE);

    makeRunningAppsLabel(lv_scr_act(), 102, 9, 82);
    makeBatteryBadge(lv_scr_act());

    lv_obj_t *list = makeVerticalList(
        6, 40, 228, 194, 14 * 48, &appsScrollOffset);
    makeAppMenuRow(
        list, "MAP", 3, static_cast<intptr_t>(View::MAP));
    makeAppMenuRow(
        list, "MENUS", 51, static_cast<intptr_t>(View::NEARBY));
    makeAppMenuRow(
        list, "STRAINS", 99, static_cast<intptr_t>(View::STRAINS));
    makeAppMenuRow(
        list, "STOPWATCH", 147,
        static_cast<intptr_t>(View::STOPWATCH));
    makeAppMenuRow(
        list, "COUNTDOWN", 195, static_cast<intptr_t>(View::TIMER));
    makeAppMenuRow(
        list, "INTERVAL TIMER", 243,
        static_cast<intptr_t>(View::INTERVAL));
    makeAppMenuRow(
        list, "ALARM", 291, static_cast<intptr_t>(View::ALARM));
    makeAppMenuRow(
        list, "STEPS", 339, static_cast<intptr_t>(View::STEPS));
    makeAppMenuRow(
        list, "SPEEDOMETER", 387,
        static_cast<intptr_t>(View::SPEEDOMETER));
    makeAppMenuRow(
        list, "TORCH", 435, static_cast<intptr_t>(View::TORCH));
    makeAppMenuRow(
        list, "TV POWER", 483, static_cast<intptr_t>(View::IR));
    makeAppMenuRow(
        list, "WI-FI ADVERTISING", 531,
        static_cast<intptr_t>(View::WIFI_AP));
    makeAppMenuRow(
        list, "BATTERY", 579, static_cast<intptr_t>(View::BATTERY));
    makeAppMenuRow(
        list, "SETTINGS", 627,
        static_cast<intptr_t>(View::SETTINGS));
}

static void buildNearbyView()
{
    prepareScreen();
    makeButton(
        lv_scr_act(), menusGroupOpen ? "A-Z" : "Apps",
        6, 5, 66, 36,
        menusGroupOpen
            ? 17099
            : ACTION_OPEN_APPS);
    makeBatteryBadge(lv_scr_act());
    makeButton(lv_scr_act(), "GPS", 174, 45, 60, 34, 300);

    lv_obj_t *title = makeLabel(
        lv_scr_act(), 11, 108, LV_TEXT_ALIGN_CENTER);
    lv_obj_set_pos(title, 76, 11);
    containLabel(title, 24);
    lv_obj_set_style_text_font(title, &lv_font_montserrat_14, 0);
    lv_obj_set_style_text_color(title, lv_color_hex(THEME_ACCENT), 0);
    lv_label_set_long_mode(title, LV_LABEL_LONG_DOT);

    statusLabel = makeLabel(
        lv_scr_act(), 53, 158, LV_TEXT_ALIGN_LEFT);
    lv_obj_set_x(statusLabel, 10);
    containLabel(statusLabel, 18);
    lv_obj_set_style_text_color(
        statusLabel, lv_color_hex(THEME_MUTED), 0);
    lv_obj_set_style_text_font(statusLabel, &lv_font_montserrat_12, 0);

    uint16_t letterCounts[ALPHABET_BUCKET_COUNT] = {};
    uint16_t favouriteCount = 0;
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        const char *name =
            bfwatchString(BFWATCH_SHOPS[index].nameOffset);
        ++letterCounts[alphabetBucket(name)];
        if (isShopFavourite(index)) {
            ++favouriteCount;
        }
    }

    if (!menusGroupOpen) {
        lv_label_set_text(title, "MENUS A-Z");
        lv_label_set_text(statusLabel, "Choose group or letter");
        uint8_t populatedLetters = 0;
        for (uint8_t bucket = 0;
             bucket < ALPHABET_BUCKET_COUNT; ++bucket) {
            if (letterCounts[bucket] > 0) {
                ++populatedLetters;
            }
        }
        const uint8_t groupCount =
            1 + (favouriteCount > 0 ? 1 : 0) + populatedLetters;
        lv_obj_t *list = makeVerticalList(
            6, 84, 228, 150,
            max(150L, static_cast<int32_t>(groupCount) * 48),
            &menusScrollOffset);
        uint8_t position = 0;
        char row[64];
        snprintf(row, sizeof(row), "ALL SHOPS\n%u shops",
                 static_cast<unsigned>(BFWATCH_SHOP_COUNT));
        makeListButton(list, row, position * 48 + 3, 17000);
        ++position;
        if (favouriteCount > 0) {
            snprintf(row, sizeof(row), "FAVOURITES\n%u shop%s",
                     static_cast<unsigned>(favouriteCount),
                     favouriteCount == 1 ? "" : "s");
            makeListButton(list, row, position * 48 + 3, 17001);
            ++position;
        }
        for (uint8_t bucket = 0;
             bucket < ALPHABET_BUCKET_COUNT; ++bucket) {
            if (letterCounts[bucket] == 0) {
                continue;
            }
            const char letter = bucket == ALPHABET_OTHER_BUCKET
                ? '#' : static_cast<char>('A' + bucket);
            snprintf(row, sizeof(row), "%c\n%u shop%s",
                     letter,
                     static_cast<unsigned>(letterCounts[bucket]),
                     letterCounts[bucket] == 1 ? "" : "s");
            makeListButton(
                list, row, position * 48 + 3,
                17100 + static_cast<intptr_t>(bucket));
            ++position;
        }
        return;
    }

    if (menusActiveGroup == -1) {
        lv_label_set_text(title, "ALL SHOPS");
    } else if (menusActiveGroup == -2) {
        lv_label_set_text(title, "FAV SHOPS");
    } else {
        const char letter =
            menusActiveGroup == ALPHABET_OTHER_BUCKET
                ? '#'
                : static_cast<char>('A' + menusActiveGroup);
        char heading[20];
        snprintf(heading, sizeof(heading), "%c SHOPS", letter);
        lv_label_set_text(title, heading);
    }
    if (menusActiveGroup == -2) {
        lv_label_set_text(statusLabel, "Saved favourites");
    } else if (haveFix &&
               insideAmsterdam(lastLatitude, lastLongitude)) {
        lv_label_set_text(statusLabel, "Favourites, then distance");
    } else {
        lv_label_set_text(statusLabel, "Favourites, then A-Z");
    }

    rebuildShopDisplayOrder();
    uint16_t visibleCount = 0;
    for (size_t position = 0;
         position < BFWATCH_SHOP_COUNT; ++position) {
        const size_t index = shopDisplayOrder[position];
        const char *name =
            bfwatchString(BFWATCH_SHOPS[index].nameOffset);
        const bool visible =
            menusActiveGroup == -1 ||
            (menusActiveGroup == -2 && isShopFavourite(index)) ||
            (menusActiveGroup >= 0 &&
             alphabetBucket(name) ==
                 static_cast<uint8_t>(menusActiveGroup));
        if (visible) {
            ++visibleCount;
        }
    }
    lv_obj_t *list = makeVerticalList(
        6, 84, 228, 150,
        max(150L, static_cast<int32_t>(visibleCount) * 48),
        &menusScrollOffset);
    if (visibleCount == 0) {
        lv_obj_t *empty = makeLabel(
            list, 64, 218, LV_TEXT_ALIGN_CENTER);
        lv_obj_set_x(empty, 4);
        containLabel(empty, 22);
        lv_label_set_text(empty, "No shops in this group");
        lv_obj_set_style_text_color(
            empty, lv_color_hex(THEME_MUTED), 0);
        return;
    }
    const bool showLogos = loadMenuLogoBuffer();

    uint16_t visiblePosition = 0;
    for (size_t orderPosition = 0;
         orderPosition < BFWATCH_SHOP_COUNT; ++orderPosition) {
        const size_t index = shopDisplayOrder[orderPosition];
        const char *name = bfwatchString(BFWATCH_SHOPS[index].nameOffset);
        const bool favourite = isShopFavourite(index);
        const bool visible =
            menusActiveGroup == -1 ||
            (menusActiveGroup == -2 && favourite) ||
            (menusActiveGroup >= 0 &&
             alphabetBucket(name) ==
                 static_cast<uint8_t>(menusActiveGroup));
        if (!visible) {
            continue;
        }
        const int logoNameLength = favourite ? 16 : 20;
        char row[80];
        if (haveFix && insideAmsterdam(lastLatitude, lastLongitude)) {
            char distance[20];
            formatDistance(distanceToShop(index), distance, sizeof(distance));
            if (showLogos) {
                snprintf(row, sizeof(row), "%s%.*s\n%s",
                         favourite ? "FAV  " : "",
                         logoNameLength, name, distance);
            } else {
                snprintf(row, sizeof(row), "%s%.25s  %s",
                         favourite ? "FAV  " : "",
                         name, distance);
            }
        } else {
            const int maximumNameLength = showLogos ? logoNameLength : 31;
            snprintf(row, sizeof(row), "%s%.*s",
                     favourite ? "FAV  " : "",
                     maximumNameLength, name);
        }
        lv_obj_t *button = makeListButton(
            list, row, visiblePosition * 48 + 3,
            6000 + static_cast<intptr_t>(index));
        if (showLogos) {
            addMenuRowLogo(button, index);
        }
        ++visiblePosition;
    }
}

static uint16_t strainStockistCount(const char *strainName)
{
    uint16_t count = 0;
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        if (shopStocksStrain(index, strainName)) {
            ++count;
        }
    }
    return count;
}

static void buildStrainsView()
{
    prepareScreen();
    makeButton(
        lv_scr_act(), strainLetterOpen ? "A-Z" : "Apps",
        6, 5, 54, 36,
        strainLetterOpen
            ? 1506
            : ACTION_OPEN_APPS);

    lv_obj_t *title = makeLabel(lv_scr_act(), 13, 118);
    lv_obj_set_pos(title, 66, 13);
    containLabel(title, 24);
    lv_obj_set_style_text_font(title, &lv_font_montserrat_14, 0);
    lv_obj_set_style_text_color(title, lv_color_hex(THEME_ACCENT), 0);
    lv_label_set_long_mode(title, LV_LABEL_LONG_DOT);
    makeBatteryBadge(lv_scr_act());

    if (!buildStrainCatalog()) {
        lv_label_set_text(title, "STRAINS");
        lv_obj_t *message = makeLabel(lv_scr_act(), 76, 210);
        containLabel(message, 60, LV_LABEL_LONG_WRAP);
        lv_label_set_text(
            message,
            "Full menus are required.\n"
            "Generate and upload menus.bin.");
        lv_obj_set_style_text_color(
            message, lv_color_hex(THEME_MUTED), 0);
        return;
    }

    uint16_t letterCounts[ALPHABET_BUCKET_COUNT] = {};
    for (uint32_t index = 0; index < strainCatalogCount; ++index) {
        ++letterCounts[alphabetBucket(strainCatalogNames[index])];
    }

    if (!strainLetterOpen) {
        lv_label_set_text(title, "STRAINS A-Z");
        uint8_t visibleLetters = 0;
        for (uint8_t bucket = 0;
             bucket < ALPHABET_BUCKET_COUNT; ++bucket) {
            if (letterCounts[bucket] > 0) {
                ++visibleLetters;
            }
        }
        lv_obj_t *list = makeVerticalList(
            6, 48, 228, 186,
            max(186L, static_cast<int32_t>(visibleLetters + 1) * 48),
            &strainsScrollOffset);
        char favouriteRow[64];
        snprintf(
            favouriteRow, sizeof(favouriteRow),
            "FAVOURITES\n%u strain%s",
            static_cast<unsigned>(favouriteStrainCount),
            favouriteStrainCount == 1 ? "" : "s");
        lv_obj_t *favouriteButton = makeListButton(
            list, favouriteRow, 3, 15999);
        lv_obj_t *favouriteLabel =
            lv_obj_get_child(favouriteButton, 0);
        if (favouriteLabel != nullptr) {
            lv_obj_set_style_text_font(
                favouriteLabel, &lv_font_montserrat_12, 0);
            lv_obj_set_style_text_color(
                favouriteLabel, lv_color_hex(THEME_GOLD), 0);
        }
        uint8_t position = 1;
        for (uint8_t bucket = 0;
             bucket < ALPHABET_BUCKET_COUNT; ++bucket) {
            if (letterCounts[bucket] == 0) {
                continue;
            }
            const char letter = bucket == ALPHABET_OTHER_BUCKET
                ? '#' : static_cast<char>('A' + bucket);
            char row[64];
            snprintf(row, sizeof(row), "%c\n%u strain%s",
                     letter,
                     static_cast<unsigned>(letterCounts[bucket]),
                     letterCounts[bucket] == 1 ? "" : "s");
            lv_obj_t *button = makeListButton(
                list, row, position * 48 + 3,
                16000 + static_cast<intptr_t>(bucket));
            lv_obj_t *label = lv_obj_get_child(button, 0);
            if (label != nullptr) {
                lv_obj_set_style_text_font(
                    label, &lv_font_montserrat_12, 0);
            }
            ++position;
        }
        return;
    }

    uint16_t visible = 0;
    if (strainFavouritesOpen) {
        lv_label_set_text(title, "FAV STRAINS");
        for (uint32_t index = 0;
             index < strainCatalogCount; ++index) {
            if (isStrainFavourite(strainCatalogNames[index])) {
                ++visible;
            }
        }
    } else {
        const char letter =
            strainActiveLetter == ALPHABET_OTHER_BUCKET
                ? '#'
                : static_cast<char>('A' + strainActiveLetter);
        char heading[24];
        snprintf(heading, sizeof(heading), "%c STRAINS", letter);
        lv_label_set_text(title, heading);
        visible = letterCounts[strainActiveLetter];
    }
    lv_obj_t *list = makeVerticalList(
        6, 48, 228, 186,
        max(186L, static_cast<int32_t>(visible) * 48),
        &strainsScrollOffset);
    if (visible == 0) {
        lv_obj_t *empty = makeLabel(
            list, 66, 218, LV_TEXT_ALIGN_CENTER);
        lv_obj_set_x(empty, 4);
        containLabel(empty, 22);
        lv_label_set_text(
            empty, "No favourite strains yet");
        lv_obj_set_style_text_color(
            empty, lv_color_hex(THEME_MUTED), 0);
        return;
    }
    uint16_t position = 0;
    for (uint32_t catalogIndex = 0;
         catalogIndex < strainCatalogCount; ++catalogIndex) {
        const char *name = strainCatalogNames[catalogIndex];
        const bool favourite = isStrainFavourite(name);
        if ((strainFavouritesOpen && !favourite) ||
            (!strainFavouritesOpen &&
             alphabetBucket(name) != strainActiveLetter)) {
            continue;
        }
        const uint16_t stockists = strainStockistCount(name);
        const bool selected =
            selectedStrainName[0] != '\0' &&
            strcasecmp(selectedStrainName, name) == 0;
        char row[128];
        snprintf(row, sizeof(row), "%s%s%.24s\n%u shop%s",
                 selected ? "ACTIVE  " : "",
                 favourite ? "FAV  " : "",
                 name,
                 static_cast<unsigned>(stockists),
                 stockists == 1 ? "" : "s");
        lv_obj_t *button = makeListButton(
            list, row, position * 48 + 3,
            10000 + static_cast<intptr_t>(catalogIndex));
        lv_obj_t *label = lv_obj_get_child(button, 0);
        if (label != nullptr) {
            lv_obj_set_style_text_font(
                label, &lv_font_montserrat_12, 0);
        }
        ++position;
    }
}

static void buildStrainShopsView()
{
    if (selectedStrainName[0] == '\0') {
        navigateBack(View::STRAINS);
        return;
    }

    prepareScreen();
    makeButton(lv_scr_act(), "Back", 6, 5, 56, 36, 1503);
    makeButton(
        lv_scr_act(),
        isStrainFavourite(selectedStrainName) ? "Unfav" : "Fav",
        64, 5, 56, 36, 1504);
    makeButton(lv_scr_act(), "Map", 122, 5, 62, 36, 1502);
    makeBatteryBadge(lv_scr_act());

    lv_obj_t *title = makeLabel(
        lv_scr_act(), 45, 226, LV_TEXT_ALIGN_CENTER);
    lv_obj_set_pos(title, 7, 45);
    lv_obj_set_height(title, 20);
    lv_label_set_long_mode(title, LV_LABEL_LONG_SCROLL_CIRCULAR);
    lv_label_set_text(title, selectedStrainName);
    lv_obj_set_style_text_font(title, &lv_font_montserrat_14, 0);
    lv_obj_set_style_text_color(title, lv_color_hex(THEME_GOLD), 0);

    rebuildStrainShopOrder();
    char status[64];
    snprintf(status, sizeof(status), "%u current stockist%s",
             static_cast<unsigned>(strainShopCount),
             strainShopCount == 1 ? "" : "s");
    lv_obj_t *countLabel = makeLabel(lv_scr_act(), 67, 226);
    containLabel(countLabel, 18);
    lv_label_set_text(countLabel, status);
    lv_obj_set_style_text_font(
        countLabel, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(
        countLabel, lv_color_hex(THEME_MUTED), 0);

    const int32_t contentHeight = max(
        147L, static_cast<int32_t>(strainShopCount) * 48);
    lv_obj_t *list = makeVerticalList(
        6, 87, 228, 147, contentHeight,
        &strainShopsScrollOffset);
    if (strainShopCount == 0) {
        lv_obj_t *empty = makeLabel(
            list, 60, 176, LV_TEXT_ALIGN_CENTER);
        lv_obj_set_x(empty, 6);
        containLabel(empty, 22);
        lv_label_set_text(empty, "No current stockists");
        lv_obj_set_style_text_color(
            empty, lv_color_hex(THEME_MUTED), 0);
        return;
    }

    const bool showLogos = loadMenuLogoBuffer();
    for (size_t position = 0; position < strainShopCount; ++position) {
        const size_t index = strainShopOrder[position];
        const char *name =
            bfwatchString(BFWATCH_SHOPS[index].nameOffset);
        const bool favourite = isShopFavourite(index);
        MenuStrainView offering = {};
        shopStrainOffer(index, selectedStrainName, offering);
        char row[96];
        if (haveFix && insideAmsterdam(lastLatitude, lastLongitude)) {
            char distance[20];
            formatDistance(distanceToShop(index), distance, sizeof(distance));
            snprintf(row, sizeof(row),
                     "%s%.*s\nEUR %u.%02u/g  //  %s",
                     favourite ? "FAV  " : "",
                     showLogos ? 20 : 27, name,
                     offering.priceCents / 100,
                     offering.priceCents % 100,
                     distance);
        } else {
            snprintf(row, sizeof(row), "%s%.*s\nEUR %u.%02u/g",
                     favourite ? "FAV  " : "",
                     showLogos ? 20 : 29, name,
                     offering.priceCents / 100,
                     offering.priceCents % 100);
        }
        lv_obj_t *button = makeListButton(
            list, row, position * 48 + 3,
            6000 + static_cast<intptr_t>(index));
        if (showLogos) {
            addMenuRowLogo(button, index);
        }
    }
}

static uint32_t strainNameColour(uint8_t type, uint8_t flags)
{
    if (flags & WATCH_STRAIN_CALI) {
        return 0xE88966;
    }
    switch (type) {
    case WATCH_STRAIN_INDICA: return 0xC6A3DC;
    case WATCH_STRAIN_SATIVA: return 0xE5B65D;
    case WATCH_STRAIN_HYBRID: return 0x76C6B2;
    case WATCH_STRAIN_KUSH:   return 0x9FC67B;
    default:                  return THEME_TEXT;
    }
}

static void buildShopView()
{
    if (detailShopIndex < 0 ||
        detailShopIndex >= static_cast<int16_t>(BFWATCH_SHOP_COUNT)) {
        navigateBack(View::NEARBY);
        return;
    }

    prepareScreen();
    makeButton(lv_scr_act(), "Back", 6, 5, 56, 36, 702);
    makeButton(lv_scr_act(),
               isShopFavourite(detailShopIndex) ? "Unfav" : "Fav",
               64, 5, 56, 36, 700);
    makeButton(lv_scr_act(), "Map", 122, 5, 62, 36, 701);
    makeBatteryBadge(lv_scr_act());

    const size_t index = static_cast<size_t>(detailShopIndex);
    const WatchShopRecord &shop = BFWATCH_SHOPS[index];
    uint16_t menuTotal = 0;
    uint16_t strainCount = 0;
    shopMenuCounts(index, menuTotal, strainCount);
    const bool haveShopLogo = addShopHeaderLogo(index);

    primaryLabel = makeLabel(
        lv_scr_act(), 45, haveShopLogo ? 178 : 226,
        haveShopLogo ? LV_TEXT_ALIGN_LEFT : LV_TEXT_ALIGN_CENTER);
    if (haveShopLogo) {
        lv_obj_set_x(primaryLabel, 55);
    }
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_20, 0);
    lv_obj_set_height(primaryLabel, 25);
    lv_label_set_long_mode(primaryLabel, LV_LABEL_LONG_DOT);
    lv_label_set_text(primaryLabel, bfwatchString(shop.nameOffset));
    lv_obj_set_style_text_color(primaryLabel, lv_color_hex(THEME_GOLD), 0);

    secondaryLabel = makeLabel(
        lv_scr_act(), 71, haveShopLogo ? 178 : 224,
        haveShopLogo ? LV_TEXT_ALIGN_LEFT : LV_TEXT_ALIGN_CENTER);
    if (haveShopLogo) {
        lv_obj_set_x(secondaryLabel, 55);
    }
    lv_obj_set_style_text_font(secondaryLabel, &lv_font_montserrat_12, 0);
    containLabel(secondaryLabel, 18);
    lv_obj_set_style_text_color(
        secondaryLabel, lv_color_hex(THEME_MUTED), 0);
    char detail[112];
    if (haveFix) {
        char distance[20];
        formatDistance(distanceToShop(index), distance, sizeof(distance));
        snprintf(detail, sizeof(detail),
                 "%s  //  %u items", distance, menuTotal);
    } else {
        snprintf(detail, sizeof(detail),
                 "GPS for distance  //  %u current items", menuTotal);
    }
    lv_label_set_text(secondaryLabel, detail);

    const int32_t wantedStrainHeight =
        static_cast<int32_t>(strainCount) * 46;
    const int32_t strainContentHeight =
        wantedStrainHeight > 138 ? wantedStrainHeight : 138;
    lv_obj_t *strainList = makeVerticalList(
        6, 94, 228, 140, strainContentHeight,
        &shopStrainScrollOffset);

    if (strainCount == 0) {
        lv_obj_t *empty = lv_label_create(strainList);
        lv_obj_set_pos(empty, 8, 48);
        lv_obj_set_size(empty, 210, 22);
        lv_label_set_long_mode(empty, LV_LABEL_LONG_DOT);
        lv_obj_set_style_text_align(empty, LV_TEXT_ALIGN_CENTER, 0);
        lv_obj_set_style_text_color(
            empty, lv_color_hex(THEME_MUTED), 0);
        lv_label_set_text(empty, "No active menu snapshot");
    } else {
        for (uint16_t i = 0; i < strainCount; ++i) {
            MenuStrainView strain = {};
            if (!shopMenuStrain(index, i, strain)) {
                break;
            }
            lv_obj_t *line = lv_label_create(strainList);
            lv_obj_set_pos(line, 8, i * 46 + 6);
            lv_obj_set_width(line, 210);
            lv_obj_set_height(line, 40);
            lv_label_set_long_mode(line, LV_LABEL_LONG_DOT);
            lv_obj_set_style_text_color(
                line, lv_color_hex(THEME_TEXT), 0);
            lv_obj_set_style_text_align(line, LV_TEXT_ALIGN_LEFT, 0);
            lv_label_set_recolor(line, true);
            lv_obj_add_flag(line, LV_OBJ_FLAG_CLICKABLE);
            lv_obj_clear_flag(line, LV_OBJ_FLAG_GESTURE_BUBBLE);
            lv_obj_add_event_cb(
                line, buttonEvent, LV_EVENT_CLICKED,
                reinterpret_cast<void *>(
                    20000 + static_cast<intptr_t>(i)));
            char text[112];
            snprintf(text, sizeof(text),
                     "#%06lX %s#\n#%06lX %sEUR %u.%02u/g#",
                     static_cast<unsigned long>(
                         strainNameColour(strain.type, strain.flags)),
                     strain.name,
                     static_cast<unsigned long>(THEME_MUTED),
                     strain.flags & WATCH_STRAIN_CALI ? "CALI  " : "",
                     strain.priceCents / 100,
                     strain.priceCents % 100);
            lv_label_set_text(line, text);
        }
    }
}

static void buildStopwatchView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("STOPWATCH");
    makeReadoutPanel(53, 95);

    primaryLabel = makeLabel(lv_scr_act(), 68, 228);
    containLabel(primaryLabel, 36);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_28, 0);
    secondaryLabel = makeLabel(lv_scr_act(), 108, 220);
    containLabel(secondaryLabel, 38);

    makeButton(lv_scr_act(), "Start/Pause", 8, 160, 104, 62, 100);
    makeButton(lv_scr_act(), "Lap", 118, 160, 52, 62, 102);
    makeButton(lv_scr_act(), "Reset", 176, 160, 56, 62, 101);
}

static void buildSpeedometerView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("SPEEDOMETER");
    makeReadoutPanel(43, 128);

    primaryLabel = makeLabel(lv_scr_act(), 48, 228);
    containLabel(primaryLabel, 56);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_48, 0);
    lv_obj_set_style_text_color(primaryLabel, lv_color_hex(THEME_GOLD), 0);
    secondaryLabel = makeLabel(lv_scr_act(), 108, 224);
    containLabel(secondaryLabel, 34);
    lv_obj_set_style_text_color(
        secondaryLabel, lv_color_hex(THEME_TEXT), 0);
    statusLabel = makeLabel(lv_scr_act(), 142, 224);
    containLabel(statusLabel, 22);
    lv_obj_set_style_text_color(statusLabel, lv_color_hex(THEME_MUTED), 0);

    makeButton(
        lv_scr_act(), speedometerRunning ? "Stop" : "Start",
        8, 181, 145, 51, 1100);
    makeButton(lv_scr_act(), "Reset", 161, 181, 71, 51, 1101);
}

static void buildAlarmView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("ALARM");
    makeReadoutPanel(44, 93);

    primaryLabel = makeLabel(lv_scr_act(), 49, 224);
    containLabel(primaryLabel, 45);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_40, 0);
    lv_obj_set_style_text_color(primaryLabel, lv_color_hex(THEME_GOLD), 0);
    secondaryLabel = makeLabel(lv_scr_act(), 96, 224);
    containLabel(secondaryLabel, 20);
    statusLabel = makeLabel(lv_scr_act(), 119, 224);
    containLabel(statusLabel, 20);
    lv_obj_set_style_text_color(statusLabel, lv_color_hex(THEME_MUTED), 0);

    if (alertRinging && alertSource == AlertSource::CLOCK) {
        makeButton(lv_scr_act(), "Stop", 8, 165, 108, 58, 1204);
        makeButton(lv_scr_act(), "Snooze 5m", 124, 165, 108, 58, 1205);
    } else {
        makeButton(lv_scr_act(), "-", 8, 145, 66, 38, 1200);
        makeButton(lv_scr_act(), "Next", 87, 145, 66, 38, 1201);
        makeButton(lv_scr_act(), "+", 166, 145, 66, 38, 1202);
        makeButton(
            lv_scr_act(),
            clockAlarmEnabled ? "Disable alarm" : "Enable alarm",
            45, 191, 150, 40, 1203);
    }
}

static void buildIntervalView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("INTERVAL TIMER");
    makeReadoutPanel(43, 82);

    primaryLabel = makeLabel(lv_scr_act(), 48, 228);
    containLabel(primaryLabel, 36);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_32, 0);
    secondaryLabel = makeLabel(lv_scr_act(), 87, 224);
    containLabel(secondaryLabel, 20);
    statusLabel = makeLabel(lv_scr_act(), 108, 224);
    containLabel(statusLabel, 20);
    lv_obj_set_style_text_color(statusLabel, lv_color_hex(THEME_MUTED), 0);

    makeButton(lv_scr_act(), "W-", 8, 132, 50, 36, 1300);
    makeButton(lv_scr_act(), "W+", 66, 132, 50, 36, 1301);
    makeButton(lv_scr_act(), "B-", 124, 132, 50, 36, 1302);
    makeButton(lv_scr_act(), "B+", 182, 132, 50, 36, 1305);
    makeButton(
        lv_scr_act(), intervalRunning ? "Pause" : "Start",
        8, 178, 145, 53, 1303);
    makeButton(lv_scr_act(), "Reset", 161, 178, 71, 53, 1304);
}

static void buildStepsView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("STEPS");
    makeReadoutPanel(52, 104);

    primaryLabel = makeLabel(lv_scr_act(), 65, 224);
    containLabel(primaryLabel, 46);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_40, 0);
    lv_obj_set_style_text_color(primaryLabel, lv_color_hex(THEME_GOLD), 0);
    secondaryLabel = makeLabel(lv_scr_act(), 118, 220);
    containLabel(secondaryLabel, 24);
    lv_label_set_text(
        secondaryLabel,
        motionSensorReady ? "Hardware pedometer" : "Sensor unavailable");
    makeButton(lv_scr_act(), "Reset steps", 45, 174, 150, 50, 1400);
}

static void buildBatteryView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("BATTERY");
    makeReadoutPanel(47, 134);
    primaryLabel = makeLabel(lv_scr_act(), 60, 224);
    containLabel(primaryLabel, 46);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_40, 0);
    lv_obj_set_style_text_color(primaryLabel, lv_color_hex(THEME_GOLD), 0);
    secondaryLabel = makeLabel(lv_scr_act(), 118, 220);
    containLabel(secondaryLabel, 32);
    statusLabel = makeLabel(lv_scr_act(), 153, 220);
    containLabel(statusLabel, 22);
    lv_obj_set_style_text_color(statusLabel, lv_color_hex(THEME_MUTED), 0);
}

static void buildTorchView()
{
    prepareScreen();
    lv_obj_t *screen = lv_scr_act();
    lv_obj_set_style_bg_color(screen, lv_color_hex(0xFFFFFF), 0);
    lv_obj_set_style_bg_opa(screen, LV_OPA_COVER, 0);
    instance.setBrightness(255);
    lv_obj_t *exit = makeButton(
        screen, "EXIT TORCH", 55, 184, 130, 44,
        ACTION_OPEN_APPS);
    lv_obj_set_style_bg_color(exit, lv_color_hex(0x18120E), 0);
    makeBatteryBadge(screen);
}

static void buildTimerView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("COUNTDOWN");
    makeReadoutPanel(48, 69);

    primaryLabel = makeLabel(lv_scr_act(), 55, 228);
    containLabel(primaryLabel, 38);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_32, 0);
    secondaryLabel = makeLabel(lv_scr_act(), 96, 220);
    containLabel(secondaryLabel, 26);

    lv_obj_t *secondsButton =
        makeButton(lv_scr_act(), "+30s", 8, 126, 50, 44, 200);
    lv_obj_t *minuteButton =
        makeButton(lv_scr_act(), "+1m", 66, 126, 50, 44, 201);
    lv_obj_t *tenMinuteButton =
        makeButton(lv_scr_act(), "+10m", 124, 126, 50, 44, 204);
    lv_obj_t *hourButton =
        makeButton(lv_scr_act(), "+1h", 182, 126, 50, 44, 205);
    lv_obj_set_style_text_font(
        lv_obj_get_child(secondsButton, 0), &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_font(
        lv_obj_get_child(minuteButton, 0), &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_font(
        lv_obj_get_child(tenMinuteButton, 0), &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_font(
        lv_obj_get_child(hourButton, 0), &lv_font_montserrat_12, 0);
    makeButton(lv_scr_act(), "Start / Pause", 8, 178, 145, 54, 202);
    makeButton(lv_scr_act(), "Clear", 161, 178, 71, 54, 203);
}

static void buildGpsView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("LOCATION");
    makeReadoutPanel(44, 121);

    primaryLabel = makeLabel(lv_scr_act(), 50, 218);
    containLabel(primaryLabel, 64, LV_LABEL_LONG_WRAP);
    secondaryLabel = makeLabel(lv_scr_act(), 126, 218);
    containLabel(secondaryLabel, 42, LV_LABEL_LONG_WRAP);
    lv_obj_set_style_text_font(
        secondaryLabel, &lv_font_montserrat_12, 0);

    makeButton(lv_scr_act(), "Get fix", 8, 173, 108, 58, 300);
    makeButton(lv_scr_act(), "Cancel", 124, 173, 108, 58, 301);
}

static void addMapMovable(lv_obj_t *object, int16_t x, int16_t y)
{
    if (object == nullptr || mapMovableCount >= MAX_MAP_MOVABLES) {
        return;
    }
    lv_obj_set_pos(object, x, y);
    mapMovables[mapMovableCount++] = {object, x, y};
}

static void addMapMarkerPoint(int16_t x, int16_t y, uint16_t shopIndex,
                              uint8_t size, uint8_t priority,
                              bool useLogo, uint32_t fill, uint32_t border)
{
    if (mapMarkerPointCount >= BFWATCH_SHOP_COUNT + 1) {
        return;
    }
    mapMarkerPoints[mapMarkerPointCount++] = {
        x, y, x, y, shopIndex, size, priority, useLogo, fill, border
    };
}

static bool mapMarkerOverlapsPlaced(
    int16_t x, int16_t y, uint8_t size, size_t placedCount)
{
    for (size_t index = 0; index < placedCount; ++index) {
        const MapMarkerPoint &other = mapMarkerPoints[index];
        const int32_t deltaX = x - other.x;
        const int32_t deltaY = y - other.y;
        const int32_t separation =
            (static_cast<int32_t>(size) + other.size) / 2 + 1;
        if (deltaX * deltaX + deltaY * deltaY <
            separation * separation) {
            return true;
        }
    }
    return false;
}

static bool mapMarkerPositionClear(
    int16_t x, int16_t y, uint8_t size, size_t placedCount)
{
    const int16_t radius = size / 2;
    if (x < radius + 2 || x > MAP_VIEW_SIZE - radius - 2 ||
        y < radius + 2 || y > MAP_VIEW_SIZE - radius - 2) {
        return false;
    }
    if (mapMarkerOverlapsPlaced(x, y, size, placedCount)) {
        return false;
    }
    return true;
}

static void resolveMapMarkerCollisions()
{
    if (mapZoom < 13 || mapMarkerPointCount < 2) {
        return;
    }

    // Keep selected and favourite/filtered markers closest to their true
    // coordinate; ordinary markers yield to them when positions collide.
    for (size_t index = 1; index < mapMarkerPointCount; ++index) {
        const MapMarkerPoint marker = mapMarkerPoints[index];
        size_t insertion = index;
        while (insertion > 0 &&
               mapMarkerPoints[insertion - 1].priority <
                   marker.priority) {
            mapMarkerPoints[insertion] =
                mapMarkerPoints[insertion - 1];
            --insertion;
        }
        mapMarkerPoints[insertion] = marker;
    }

    // Search every one-pixel radius in sixteen directions. This finds the
    // nearest clear position instead of jumping markers onto wide spokes.
    static constexpr int16_t directions[][2] = {
        {1000, 0}, {924, 383}, {707, 707}, {383, 924},
        {0, 1000}, {-383, 924}, {-707, 707}, {-924, 383},
        {-1000, 0}, {-924, -383}, {-707, -707}, {-383, -924},
        {0, -1000}, {383, -924}, {707, -707}, {924, -383}
    };

    for (size_t markerIndex = 1;
        markerIndex < mapMarkerPointCount; ++markerIndex) {
        MapMarkerPoint &marker = mapMarkerPoints[markerIndex];
        if (!mapMarkerOverlapsPlaced(
                marker.x, marker.y, marker.size, markerIndex)) {
            continue;
        }

        const uint8_t directionStart =
            static_cast<uint8_t>(marker.shopIndex % 16U);
        bool positioned = false;
        for (int16_t radius = 1; radius <= 64; ++radius) {
            for (uint8_t attempt = 0; attempt < 16; ++attempt) {
                const uint8_t direction =
                    (directionStart + attempt) % 16U;
                const int32_t scaledX =
                    static_cast<int32_t>(
                        directions[direction][0]) * radius;
                const int32_t scaledY =
                    static_cast<int32_t>(
                        directions[direction][1]) * radius;
                const int16_t candidateX =
                    marker.anchorX +
                    static_cast<int16_t>(
                        scaledX >= 0
                            ? (scaledX + 500) / 1000
                            : (scaledX - 500) / 1000);
                const int16_t candidateY =
                    marker.anchorY +
                    static_cast<int16_t>(
                        scaledY >= 0
                            ? (scaledY + 500) / 1000
                            : (scaledY - 500) / 1000);
                if (mapMarkerPositionClear(
                        candidateX, candidateY,
                        marker.size, markerIndex)) {
                    marker.x = candidateX;
                    marker.y = candidateY;
                    positioned = true;
                    break;
                }
            }
            if (positioned) {
                break;
            }
        }
    }
}

static lv_color32_t mapOverlayColour(uint32_t rgb)
{
    lv_color32_t colour = {};
    colour.red = (rgb >> 16) & 0xFF;
    colour.green = (rgb >> 8) & 0xFF;
    colour.blue = rgb & 0xFF;
    colour.alpha = 0xFF;
    return colour;
}

static void setMapOverlayPixel(int16_t x, int16_t y, lv_color32_t colour)
{
    if (mapOverlayBuffer == nullptr ||
        x < 0 || x >= MAP_VIEW_SIZE || y < 0 || y >= MAP_VIEW_SIZE) {
        return;
    }
    lv_color32_t *row = reinterpret_cast<lv_color32_t *>(
        mapOverlayBuffer + static_cast<size_t>(y) * mapOverlayStride);
    row[x] = colour;
}

static void paintMapOverlayCircle(size_t markerIndex)
{
    const MapMarkerPoint &marker = mapMarkerPoints[markerIndex];
    const int16_t radius = marker.size / 2;
    const int16_t inset = marker.size >= 10 ? 2 : 1;
    const int16_t innerRadius = radius > inset ? radius - inset : 0;
    const int16_t radiusSquared = radius * radius;
    const int16_t innerSquared = innerRadius * innerRadius;
    const lv_color32_t fill = mapOverlayColour(marker.fill);
    const lv_color32_t border = mapOverlayColour(marker.border);

    for (int16_t y = -radius; y <= radius; ++y) {
        for (int16_t x = -radius; x <= radius; ++x) {
            const int16_t distanceSquared = x * x + y * y;
            if (distanceSquared <= radiusSquared) {
                setMapOverlayPixel(
                    marker.x + x, marker.y + y,
                    distanceSquared <= innerSquared ? fill : border);
            }
        }
    }
}

static void blendMapOverlayPixel(
    int16_t x, int16_t y, const lv_color32_t &source)
{
    if (mapOverlayBuffer == nullptr || source.alpha == 0 ||
        x < 0 || x >= MAP_VIEW_SIZE || y < 0 || y >= MAP_VIEW_SIZE) {
        return;
    }
    lv_color32_t *row = reinterpret_cast<lv_color32_t *>(
        mapOverlayBuffer + static_cast<size_t>(y) * mapOverlayStride);
    lv_color32_t &destination = row[x];
    if (source.alpha == 255 || destination.alpha == 0) {
        destination = source;
        return;
    }

    const uint32_t sourceAlpha = source.alpha;
    const uint32_t backgroundAlpha =
        static_cast<uint32_t>(destination.alpha) *
        (255U - sourceAlpha) / 255U;
    const uint32_t outputAlpha = sourceAlpha + backgroundAlpha;
    if (outputAlpha == 0) {
        destination = {};
        return;
    }
    destination.red = static_cast<uint8_t>(
        (source.red * sourceAlpha +
         destination.red * backgroundAlpha) / outputAlpha);
    destination.green = static_cast<uint8_t>(
        (source.green * sourceAlpha +
         destination.green * backgroundAlpha) / outputAlpha);
    destination.blue = static_cast<uint8_t>(
        (source.blue * sourceAlpha +
         destination.blue * backgroundAlpha) / outputAlpha);
    destination.alpha = static_cast<uint8_t>(outputAlpha);
}

static lv_color32_t sampleCompactLogoPixel(
    const lv_color32_t *pixels, uint16_t targetX, uint16_t targetY)
{
    const uint16_t sourceLeft =
        targetX * BFWATCH_LOGO_WIDTH / COMPACT_LOGO_SIZE;
    const uint16_t calculatedRight =
        (targetX + 1) * BFWATCH_LOGO_WIDTH / COMPACT_LOGO_SIZE;
    const uint16_t sourceRight =
        calculatedRight > sourceLeft ? calculatedRight : sourceLeft + 1;
    const uint16_t sourceTop =
        targetY * BFWATCH_LOGO_HEIGHT / COMPACT_LOGO_SIZE;
    const uint16_t calculatedBottom =
        (targetY + 1) * BFWATCH_LOGO_HEIGHT / COMPACT_LOGO_SIZE;
    const uint16_t sourceBottom =
        calculatedBottom > sourceTop ? calculatedBottom : sourceTop + 1;

    uint32_t alphaTotal = 0;
    uint32_t redTotal = 0;
    uint32_t greenTotal = 0;
    uint32_t blueTotal = 0;
    uint32_t sampleCount = 0;
    for (uint16_t y = sourceTop;
         y < min(sourceBottom, BFWATCH_LOGO_HEIGHT); ++y) {
        for (uint16_t x = sourceLeft;
             x < min(sourceRight, BFWATCH_LOGO_WIDTH); ++x) {
            const lv_color32_t &pixel =
                pixels[static_cast<size_t>(y) * BFWATCH_LOGO_WIDTH + x];
            alphaTotal += pixel.alpha;
            redTotal += static_cast<uint32_t>(pixel.red) * pixel.alpha;
            greenTotal += static_cast<uint32_t>(pixel.green) * pixel.alpha;
            blueTotal += static_cast<uint32_t>(pixel.blue) * pixel.alpha;
            ++sampleCount;
        }
    }

    lv_color32_t result = {};
    if (sampleCount == 0 || alphaTotal == 0) {
        return result;
    }
    result.red = static_cast<uint8_t>(redTotal / alphaTotal);
    result.green = static_cast<uint8_t>(greenTotal / alphaTotal);
    result.blue = static_cast<uint8_t>(blueTotal / alphaTotal);
    result.alpha = static_cast<uint8_t>(alphaTotal / sampleCount);
    return result;
}

static bool paintMapOverlayLogo(
    size_t markerIndex, File &logoData)
{
    const MapMarkerPoint &marker = mapMarkerPoints[markerIndex];
    if (!marker.useLogo || marker.shopIndex == UINT16_MAX ||
        !logoPackageReady || !logoData) {
        return false;
    }
    const int32_t recordIndex = findLogoRecordIndex(
        shopIdentifierHash(marker.shopIndex));
    if (recordIndex < 0) {
        return false;
    }

    const size_t spriteBytes =
        static_cast<size_t>(BFWATCH_LOGO_WIDTH) *
        BFWATCH_LOGO_HEIGHT * sizeof(lv_color32_t);
    if (mapLogoSpriteBuffer == nullptr) {
        mapLogoSpriteBuffer =
            static_cast<uint8_t *>(ps_malloc(spriteBytes));
    }
    if (mapLogoSpriteBuffer == nullptr) {
        return false;
    }

    const LogoIndexRecord &record = logoIndexRecords[recordIndex];
    if (!logoData.seek(record.offset) ||
        logoData.read(mapLogoSpriteBuffer, spriteBytes) != spriteBytes) {
        return false;
    }
    const lv_color32_t *pixels =
        reinterpret_cast<const lv_color32_t *>(mapLogoSpriteBuffer);
    const int16_t left =
        marker.x - static_cast<int16_t>(COMPACT_LOGO_SIZE / 2U);
    const int16_t top =
        marker.y - static_cast<int16_t>(COMPACT_LOGO_SIZE / 2U);
    for (uint16_t y = 0; y < COMPACT_LOGO_SIZE; ++y) {
        for (uint16_t x = 0; x < COMPACT_LOGO_SIZE; ++x) {
            blendMapOverlayPixel(
                left + x, top + y,
                sampleCompactLogoPixel(pixels, x, y));
        }
    }
    return true;
}

static void createMapMarkerOverlay()
{
    mapOverlayStride = lv_draw_buf_width_to_stride(
        MAP_VIEW_SIZE, LV_COLOR_FORMAT_ARGB8888);
    const size_t bufferSize =
        static_cast<size_t>(mapOverlayStride) * MAP_VIEW_SIZE;
    if (mapOverlayBuffer == nullptr) {
        mapOverlayBuffer = static_cast<uint8_t *>(ps_malloc(bufferSize));
    }
    if (mapOverlayBuffer == nullptr) {
        Serial.println("Map marker overlay allocation failed");
        return;
    }
    memset(mapOverlayBuffer, 0, bufferSize);

    File logoData;
    if (logoPackageReady) {
        logoData = FFat.open("/logos.bin", FILE_READ);
    }
    for (uint8_t priority = 0; priority <= 3; ++priority) {
        for (size_t index = 0; index < mapMarkerPointCount; ++index) {
            if (mapMarkerPoints[index].priority == priority) {
                const MapMarkerPoint &marker = mapMarkerPoints[index];
                const bool needsSurround =
                    marker.useLogo &&
                    marker.size > COMPACT_LOGO_SIZE;
                if (needsSurround) {
                    paintMapOverlayCircle(index);
                }
                const bool paintedLogo =
                    paintMapOverlayLogo(index, logoData);
                if (!paintedLogo && !needsSurround) {
                    paintMapOverlayCircle(index);
                }
            }
        }
    }
    logoData.close();

    lv_obj_t *canvas = lv_canvas_create(mapViewport);
    lv_canvas_set_buffer(canvas, mapOverlayBuffer,
                         MAP_VIEW_SIZE, MAP_VIEW_SIZE,
                         LV_COLOR_FORMAT_ARGB8888);
    lv_obj_clear_flag(canvas, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(canvas, LV_OBJ_FLAG_SCROLLABLE);
    addMapMovable(canvas, 0, 0);
}

static void drawMapTilesAndMarkers()
{
    mapMovableCount = 0;
    mapMarkerPointCount = 0;
    mapLoadedTileCount = 0;
    mapMissingTileCount = 0;

    const double centreWorldX =
        longitudeToWorldX(mapCenterLongitude, mapZoom);
    const double centreWorldY =
        latitudeToWorldY(mapCenterLatitude, mapZoom);
    const double leftWorld = centreWorldX - MAP_VIEW_SIZE / 2.0;
    const double topWorld = centreWorldY - MAP_VIEW_SIZE / 2.0;
    const int32_t firstTileX =
        static_cast<int32_t>(floor(leftWorld / BFWATCH_MAP_TILE_SIZE));
    const int32_t firstTileY =
        static_cast<int32_t>(floor(topWorld / BFWATCH_MAP_TILE_SIZE));
    const int32_t lastTileX =
        static_cast<int32_t>(floor(
            (leftWorld + MAP_VIEW_SIZE - 1.0) / BFWATCH_MAP_TILE_SIZE));
    const int32_t lastTileY =
        static_cast<int32_t>(floor(
            (topWorld + MAP_VIEW_SIZE - 1.0) / BFWATCH_MAP_TILE_SIZE));

    for (int32_t tileX = firstTileX; tileX <= lastTileX; ++tileX) {
        for (int32_t tileY = firstTileY; tileY <= lastTileY; ++tileY) {
            if (!mapStorageReady ||
                findMapPackEntry(mapZoom, tileX, tileY) == nullptr) {
                ++mapMissingTileCount;
                continue;
            }

            char lvglPath[64];
            snprintf(lvglPath, sizeof(lvglPath), "P:/%u/%ld/%ld.jpg",
                     mapZoom, static_cast<long>(tileX),
                     static_cast<long>(tileY));
            lv_obj_t *image = lv_image_create(mapViewport);
            lv_image_set_src(image, lvglPath);
            lv_obj_clear_flag(image, LV_OBJ_FLAG_CLICKABLE);
            lv_obj_clear_flag(image, LV_OBJ_FLAG_SCROLLABLE);
            const int16_t x = static_cast<int16_t>(lround(
                tileX * BFWATCH_MAP_TILE_SIZE - leftWorld));
            const int16_t y = static_cast<int16_t>(lround(
                tileY * BFWATCH_MAP_TILE_SIZE - topWorld));
            addMapMovable(image, x, y);
            ++mapLoadedTileCount;
        }
    }

    mapPackageReady = mapLoadedTileCount > 0;
    mapDragStartWorldX = centreWorldX;
    mapDragStartWorldY = centreWorldY;
    if (!mapPackageReady) {
        return;
    }

    const uint8_t ordinarySize = mapZoom >= 14 ? 8 : (mapZoom == 13 ? 6 : 4);
    for (size_t index = 0; index < BFWATCH_SHOP_COUNT; ++index) {
        if (mapStrainFilterActive &&
            !shopStocksStrain(index, selectedStrainName)) {
            continue;
        }
        double latitude;
        double longitude;
        shopCoordinates(index, latitude, longitude);
        const int16_t x = static_cast<int16_t>(lround(
            longitudeToWorldX(longitude, mapZoom) - leftWorld));
        const int16_t y = static_cast<int16_t>(lround(
            latitudeToWorldY(latitude, mapZoom) - topWorld));
        if (x < -12 || x > MAP_VIEW_SIZE + 12 ||
            y < -12 || y > MAP_VIEW_SIZE + 12) {
            continue;
        }

        const bool selected =
            mapFocusedShopIndex == static_cast<int16_t>(index);
        const bool favourite = isShopFavourite(index);
        const bool useLogo =
            logoPackageReady &&
            !mapStrainFilterActive &&
            (mapZoom >= 15 || favourite || selected);
        const uint8_t size = mapStrainFilterActive
            ? (useLogo
                ? (selected ? 30 : 27)
                : (selected ? 13 : (mapZoom >= 13 ? 10 : 8)))
            : (useLogo
                ? (selected ? 30 : (favourite ? 27 : 24))
                : (selected ? 13 : (favourite ? 10 : ordinarySize)));
        const uint32_t fill =
            selected ? 0xFFD166 :
            (mapStrainFilterActive ? THEME_ACCENT :
             (favourite ? 0xFF6FAE : 0x1CCB75));
        const uint32_t border =
            selected ? 0x4A3510 :
            (mapStrainFilterActive ? THEME_TEXT : 0x073D29);
        addMapMarkerPoint(
            x, y, static_cast<uint16_t>(index), size,
            selected ? 2 :
            ((mapStrainFilterActive || favourite) ? 1 : 0),
            useLogo, fill, border);
    }

    // A strain can have many stockists across Amsterdam while only a handful
    // are visible at a close zoom. Decide logo density from this viewport,
    // not the city-wide stockist total used to auto-fit the initial map.
    if (mapStrainFilterActive &&
        mapZoom >= 13 &&
        logoPackageReady &&
        mapMarkerPointCount <= STRAIN_MAP_LOGO_MAX_STOCKISTS) {
        for (size_t index = 0; index < mapMarkerPointCount; ++index) {
            MapMarkerPoint &marker = mapMarkerPoints[index];
            marker.useLogo = true;
            marker.size =
                marker.shopIndex ==
                    static_cast<uint16_t>(mapFocusedShopIndex)
                ? 30
                : 27;
        }
    }

    resolveMapMarkerCollisions();

    if (haveFix && insideAmsterdam(lastLatitude, lastLongitude)) {
        const int16_t x = static_cast<int16_t>(lround(
            longitudeToWorldX(lastLongitude, mapZoom) - leftWorld));
        const int16_t y = static_cast<int16_t>(lround(
            latitudeToWorldY(lastLatitude, mapZoom) - topWorld));
        if (x >= -12 && x <= MAP_VIEW_SIZE + 12 &&
            y >= -12 && y <= MAP_VIEW_SIZE + 12) {
            addMapMarkerPoint(
                x, y, UINT16_MAX, 15, 3, false,
                0xE63946, 0xFFFFFF);
        }
    }
    createMapMarkerOverlay();
}

static void buildMapView()
{
    Serial.printf("Map open: heap=%u psram=%u package=%u\n",
                  static_cast<unsigned>(ESP.getFreeHeap()),
                  static_cast<unsigned>(ESP.getFreePsram()),
                  mapPackageReady ? 1U : 0U);
    prepareScreen();
    if (!mapPackageReady) {
        makeButton(
            lv_scr_act(), "Back", 6, 5, 66, 36, ACTION_MAP_BACK);
        lv_obj_t *title = makeLabel(lv_scr_act(), 18, 150);
        lv_obj_set_pos(title, 82, 18);
        containLabel(title, 26);
        lv_label_set_text(title, "OFFLINE MAP");
        lv_obj_set_style_text_font(title, &lv_font_montserrat_20, 0);

        primaryLabel = makeLabel(lv_scr_act(), 75, 212);
        containLabel(primaryLabel, 72, LV_LABEL_LONG_WRAP);
        lv_label_set_text(primaryLabel,
            "Map files are incomplete.\n"
            "Run upload_watch_map.py\n"
            "while the watch is awake.");
        makeButton(lv_scr_act(), "Location", 55, 174, 130, 52, 300);
        Serial.println("Map safe screen: representative tile not installed");
        return;
    }
    if (!mapCenterInitialized) {
        resetMapCenter();
    }

    mapViewport = lv_obj_create(lv_scr_act());
    lv_obj_remove_style_all(mapViewport);
    lv_obj_set_pos(mapViewport, 0, 0);
    lv_obj_set_size(mapViewport, MAP_VIEW_SIZE, MAP_VIEW_SIZE);
    lv_obj_set_style_bg_color(mapViewport, lv_color_hex(0xF4F0E6), 0);
    lv_obj_set_style_bg_opa(mapViewport, LV_OPA_COVER, 0);
    lv_obj_clear_flag(mapViewport, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_add_flag(mapViewport, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_add_event_cb(mapViewport, mapDragEvent, LV_EVENT_ALL, nullptr);

    drawMapTilesAndMarkers();
    Serial.printf("Map ready: tiles=%u missing=%u markers=%u heap=%u psram=%u\n",
                  mapLoadedTileCount, mapMissingTileCount,
                  static_cast<unsigned>(mapMarkerPointCount),
                  static_cast<unsigned>(ESP.getFreeHeap()),
                  static_cast<unsigned>(ESP.getFreePsram()));

    makeButton(
        lv_scr_act(), "Back", 5, 5, 60, 38, ACTION_MAP_BACK);
    makeButton(lv_scr_act(), "GPS", 175, 5, 60, 38, 300);
    makeButton(lv_scr_act(), "-", 5, 195, 45, 40, 801);
    makeButton(lv_scr_act(), "Overview", 76, 195, 88, 40, 800);
    makeButton(lv_scr_act(), "+", 190, 195, 45, 40, 802);

    lv_obj_t *focusButton = makeButton(
        lv_scr_act(), "FOCUS ME", 66, 5, 108, 38, 803);
    mapStatusLabel = lv_obj_get_child(focusButton, 0);
    lv_obj_set_style_text_font(
        mapStatusLabel, &lv_font_montserrat_12, 0);
    lv_label_set_long_mode(mapStatusLabel, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_align(
        mapStatusLabel, LV_TEXT_ALIGN_CENTER, 0);
}

static void loadClockEditor()
{
    struct tm now = {};
    instance.rtc.getDateTime(&now);
    if (now.tm_year + 1900 >= 2020) {
        clockYear = now.tm_year + 1900;
        clockMonth = now.tm_mon + 1;
        clockDay = now.tm_mday;
        clockHour = now.tm_hour;
        clockMinute = now.tm_min;
    }
    clockField = ClockField::HOUR;
    clockEditorLoaded = true;
}

static void buildClockView()
{
    prepareScreen();
    makeMenuButton();
    if (!clockEditorLoaded) {
        loadClockEditor();
    }

    makeTopTitle("SET CLOCK");
    makeReadoutPanel(49, 80);

    primaryLabel = makeLabel(lv_scr_act(), 55, 224);
    containLabel(primaryLabel, 38);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_32, 0);
    secondaryLabel = makeLabel(lv_scr_act(), 94, 220);
    containLabel(secondaryLabel, 20);
    statusLabel = makeLabel(lv_scr_act(), 115, 220);
    containLabel(statusLabel, 20);
    lv_obj_set_style_text_color(statusLabel, lv_color_hex(THEME_ACCENT), 0);

    makeButton(lv_scr_act(), "-", 8, 139, 66, 45, 400);
    makeButton(lv_scr_act(), "Next", 87, 139, 66, 45, 401);
    makeButton(lv_scr_act(), "+", 166, 139, 66, 45, 402);
    makeButton(lv_scr_act(), "Save clock", 45, 192, 150, 40, 403);
}

static const char *tvProfileName()
{
    switch (tvProfile) {
    case TvProfile::LG:      return "LG";
    case TvProfile::SAMSUNG: return "Samsung";
    case TvProfile::SONY:    return "Sony";
    case TvProfile::COUNT:   break;
    }
    return "Unknown";
}

static void buildIrView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("TV POWER");
    makeReadoutPanel(47, 69);

    primaryLabel = makeLabel(lv_scr_act(), 53, 210);
    containLabel(primaryLabel, 32);
    lv_obj_set_style_text_font(primaryLabel, &lv_font_montserrat_28, 0);
    secondaryLabel = makeLabel(lv_scr_act(), 84, 220);
    containLabel(secondaryLabel, 20);
    lv_label_set_text(secondaryLabel, "Power toggle - point at TV");
    statusLabel = makeLabel(lv_scr_act(), 105, 220);
    containLabel(statusLabel, 20);
    lv_obj_set_style_text_color(statusLabel, lv_color_hex(THEME_MUTED), 0);

    makeButton(lv_scr_act(), "Previous", 8, 126, 88, 40, 500);
    makeButton(lv_scr_act(), "Next", 144, 126, 88, 40, 501);

    lv_obj_t *powerButton = lv_btn_create(lv_scr_act());
    lv_obj_set_pos(powerButton, 42, 174);
    lv_obj_set_size(powerButton, 156, 58);
    lv_obj_set_style_radius(powerButton, 16, 0);
    lv_obj_set_style_bg_color(
        powerButton, lv_color_hex(THEME_DANGER), 0);
    lv_obj_set_style_bg_color(
        powerButton, lv_color_hex(THEME_DANGER_PRESSED), LV_STATE_PRESSED);
    lv_obj_set_style_border_color(
        powerButton, lv_color_hex(THEME_ACCENT), 0);
    lv_obj_set_style_border_width(powerButton, 1, 0);
    lv_obj_set_style_shadow_width(powerButton, 0, 0);
    lv_obj_clear_flag(powerButton, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_add_flag(powerButton, LV_OBJ_FLAG_GESTURE_BUBBLE);
    lv_obj_set_ext_click_area(powerButton, 2);
    lv_obj_add_event_cb(powerButton, irPowerEvent, LV_EVENT_LONG_PRESSED, nullptr);

    lv_obj_t *powerLabel = lv_label_create(powerButton);
    lv_label_set_text(powerLabel, "Hold POWER");
    lv_obj_set_size(powerLabel, 138, 22);
    lv_label_set_long_mode(powerLabel, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_align(
        powerLabel, LV_TEXT_ALIGN_CENTER, 0);
    lv_obj_set_style_text_color(powerLabel, lv_color_hex(THEME_TEXT), 0);
    lv_obj_clear_flag(powerLabel, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_clear_flag(powerLabel, LV_OBJ_FLAG_CLICKABLE);
    lv_obj_clear_flag(powerLabel, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_center(powerLabel);
}

static void formatScreenTimeout(char *buffer, size_t bufferSize)
{
    const uint32_t seconds =
        SCREEN_TIMEOUT_OPTIONS_MS[screenTimeoutIndex] / 1000U;
    if (seconds < 60U) {
        snprintf(buffer, bufferSize, "%u SEC", seconds);
    } else {
        snprintf(buffer, bufferSize, "%u MIN", seconds / 60U);
    }
}

static void makeSettingsRow(
    lv_obj_t *parent, const char *heading, const char *value,
    int16_t rowY,
    intptr_t previousAction, intptr_t nextAction)
{
    lv_obj_t *row = lv_obj_create(parent);
    lv_obj_set_pos(row, 4, rowY);
    lv_obj_set_size(row, 218, 62);
    lv_obj_set_style_radius(row, 12, 0);
    lv_obj_set_style_bg_color(
        row, lv_color_hex(THEME_PANEL_RAISED), 0);
    lv_obj_set_style_bg_opa(row, LV_OPA_80, 0);
    lv_obj_set_style_border_color(
        row, lv_color_hex(THEME_BORDER), 0);
    lv_obj_set_style_border_width(row, 1, 0);
    lv_obj_set_style_pad_all(row, 0, 0);
    lv_obj_clear_flag(row, LV_OBJ_FLAG_SCROLLABLE);
    lv_obj_clear_flag(row, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
    lv_obj_add_flag(row, LV_OBJ_FLAG_GESTURE_BUBBLE);

    lv_obj_t *headingLabel = lv_label_create(row);
    lv_obj_set_pos(headingLabel, 10, 6);
    lv_obj_set_width(headingLabel, 198);
    lv_obj_set_height(headingLabel, 16);
    lv_obj_set_style_text_align(
        headingLabel, LV_TEXT_ALIGN_LEFT, 0);
    lv_label_set_text(headingLabel, heading);
    lv_label_set_long_mode(headingLabel, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_font(
        headingLabel, &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_color(
        headingLabel, lv_color_hex(THEME_MUTED), 0);
    lv_obj_clear_flag(headingLabel, LV_OBJ_FLAG_OVERFLOW_VISIBLE);

    lv_obj_t *previous = makeButton(
        row, "<", 8, 24, 42, 32, previousAction);
    lv_obj_t *next = makeButton(
        row, ">", 168, 24, 42, 32, nextAction);
    lv_obj_set_style_shadow_width(previous, 0, 0);
    lv_obj_set_style_shadow_width(next, 0, 0);

    lv_obj_t *valueLabel = lv_label_create(row);
    lv_obj_set_pos(valueLabel, 54, 28);
    lv_obj_set_size(valueLabel, 110, 24);
    lv_obj_set_style_text_align(
        valueLabel, LV_TEXT_ALIGN_CENTER, 0);
    lv_label_set_text(valueLabel, value);
    lv_label_set_long_mode(valueLabel, LV_LABEL_LONG_DOT);
    lv_obj_set_style_text_color(
        valueLabel, lv_color_hex(THEME_GOLD), 0);
    lv_obj_clear_flag(valueLabel, LV_OBJ_FLAG_OVERFLOW_VISIBLE);
}

static void buildSettingsView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("SETTINGS");

    char timeout[20];
    char brightness[20];
    char volume[20];
    formatScreenTimeout(timeout, sizeof(timeout));
    snprintf(
        brightness, sizeof(brightness), "%u%%",
        static_cast<unsigned>(
            (static_cast<uint16_t>(screenBrightness) * 100U + 127U) /
            255U));
    snprintf(volume, sizeof(volume), "%u%%",
             static_cast<unsigned>(alertVolumePercent));

    lv_obj_t *list = makeVerticalList(
        6, 43, 228, 191, 512, &settingsScrollOffset);
    makeSettingsRow(
        list, "GPS UPDATES", gpsUpdateModeName(), 4, 900, 901);
    makeSettingsRow(
        list, "SCREEN OFF", timeout, 70, 902, 903);
    makeSettingsRow(
        list, "BRIGHTNESS", brightness, 136, 904, 905);
    makeSettingsRow(
        list, "ALERT OUTPUT", alertModeName(), 202, 907, 908);
    makeSettingsRow(
        list, "ALERT VOLUME", volume, 268, 912, 913);
    makeSettingsRow(
        list, "SPEED UNITS", speedUnitName(), 334, 909, 910);
    makeSettingsRow(
        list, "WATCH-FACE SHOP", watchShopModeName(),
        400, 914, 915);
    lv_obj_t *raiseButton = makeButton(
        list,
        !motionSensorReady
            ? "RAISE N/A"
            : (raiseToWakeEnabled ? "RAISE ON" : "RAISE OFF"),
        4, 470, 72, 38, 906);
    lv_obj_set_style_text_font(
        lv_obj_get_child(raiseButton, 0),
        &lv_font_montserrat_12, 0);
    lv_obj_t *testButton = makeButton(
        list, alertAudioPlaying ? "STOP" : "TEST",
        81, 470, 64, 38, 911);
    audioTestButtonLabel = lv_obj_get_child(testButton, 0);
    lv_obj_t *clockButton = makeButton(
        list, "CLOCK", 150, 470, 72, 38,
        static_cast<intptr_t>(View::CLOCK));
    lv_obj_set_style_text_font(
        lv_obj_get_child(clockButton, 0),
        &lv_font_montserrat_12, 0);
}

static void buildWifiApView()
{
    prepareScreen();
    makeMenuButton();
    makeTopTitle("WI-FI ADS");

    statusLabel = makeLabel(lv_scr_act(), 49, 224);
    containLabel(statusLabel, 26);
    lv_obj_set_style_text_color(
        statusLabel, lv_color_hex(THEME_MUTED), 0);
    lv_obj_set_style_text_font(
        statusLabel, &lv_font_montserrat_12, 0);

    lv_obj_t *first = makeButton(
        lv_scr_act(), JOKE_SSIDS[0], 8, 82, 224, 46, 1000);
    lv_obj_t *second = makeButton(
        lv_scr_act(), JOKE_SSIDS[1], 8, 136, 224, 46, 1001);
    lv_obj_set_style_text_font(
        lv_obj_get_child(first, 0), &lv_font_montserrat_12, 0);
    lv_obj_set_style_text_font(
        lv_obj_get_child(second, 0), &lv_font_montserrat_12, 0);

    makeButton(lv_scr_act(), "STOP WI-FI", 55, 190, 130, 42, 1002);
}

static void buildCurrentView()
{
    if (lastBuiltView == View::TORCH && currentView != View::TORCH) {
        instance.setBrightness(screenBrightness);
    }
    if (speedometerRunning && currentView != View::SPEEDOMETER) {
        stopSpeedometer();
    }
    if (gpsAcquiring && gpsManualRequest && currentView != View::GPS) {
        mapFocusRequested = false;
        stopGpsFix("GNSS cancelled");
    }
    lastBuiltView = currentView;

    switch (currentView) {
    case View::WATCH:     buildWatchView(); break;
    case View::MENU:      buildMenuView(); break;
    case View::NEARBY:    buildNearbyView(); break;
    case View::SHOP:      buildShopView(); break;
    case View::STRAINS:   buildStrainsView(); break;
    case View::STRAIN_SHOPS: buildStrainShopsView(); break;
    case View::SPEEDOMETER: buildSpeedometerView(); break;
    case View::STOPWATCH: buildStopwatchView(); break;
    case View::TIMER:     buildTimerView(); break;
    case View::ALARM:     buildAlarmView(); break;
    case View::INTERVAL:  buildIntervalView(); break;
    case View::STEPS:     buildStepsView(); break;
    case View::BATTERY:   buildBatteryView(); break;
    case View::TORCH:     buildTorchView(); break;
    case View::GPS:       buildGpsView(); break;
    case View::MAP:       buildMapView(); break;
    case View::CLOCK:     buildClockView(); break;
    case View::IR:        buildIrView(); break;
    case View::SETTINGS:  buildSettingsView(); break;
    case View::WIFI_AP:   buildWifiApView(); break;
    }

    finishActiveListLayout();
    updateCurrentView(true);
    markActivity();
}

// -----------------------------------------------------------------------------
// View updates
// -----------------------------------------------------------------------------

static void updateWatchView()
{
    if (rotateWatchFaceShop(false)) {
        const uint32_t previousActivityMs = lastActivityMs;
        buildCurrentView();
        lastActivityMs = previousActivityMs;
        return;
    }

    struct tm now = {};
    char timeBuffer[16] = "--:--";
    char dateBuffer[48] = "RTC not set";
    instance.rtc.getDateTime(&now);
    if (now.tm_year + 1900 >= 2020) {
        strftime(timeBuffer, sizeof(timeBuffer), "%H:%M", &now);
        strftime(dateBuffer, sizeof(dateBuffer), "%a %d %b", &now);
    }

    setLabel(primaryLabel, timeBuffer);
    setLabel(secondaryLabel, dateBuffer);

    const char *shopName = "No coffeeshop data";
    char distanceBuffer[24] = "";
    const int16_t displayIndex = watchFaceShopIndex();
    if (displayIndex >= 0 &&
        displayIndex < static_cast<int16_t>(BFWATCH_SHOP_COUNT)) {
        shopName =
            bfwatchString(BFWATCH_SHOPS[displayIndex].nameOffset);
        if (haveFix) {
            formatDistance(
                distanceToShop(displayIndex),
                distanceBuffer, sizeof(distanceBuffer));
        } else {
            snprintf(distanceBuffer, sizeof(distanceBuffer), "GPS --");
        }
    }
    setLabel(tertiaryLabel, shopName);
    setLabel(shopDistanceLabel, distanceBuffer);

    int battery = instance.pmu.getBatteryPercent();
    if (battery < 0 || battery > 100) {
        setLabel(batteryLabel, "--%");
    } else {
        char batteryBuffer[16];
        snprintf(batteryBuffer, sizeof(batteryBuffer), "%d%%%s", battery,
                 instance.pmu.isVbusIn() ? "+" : "");
        setLabel(batteryLabel, batteryBuffer);
    }
}

static uint64_t stopwatchElapsedUs()
{
    if (!stopwatchRunning) {
        return stopwatchAccumulatedUs;
    }
    return stopwatchAccumulatedUs +
           static_cast<uint64_t>(monotonicUs() - stopwatchStartedUs);
}

static void updateStopwatchView()
{
    char buffer[32];
    formatDuration(stopwatchElapsedUs() / 1000ULL, true,
                   buffer, sizeof(buffer));
    setLabel(primaryLabel, buffer);
    if (stopwatchLapCount > 0) {
        char lap[64];
        char lapTime[32];
        formatDuration(
            stopwatchLapsUs[stopwatchLapCount - 1] / 1000ULL,
            true, lapTime, sizeof(lapTime));
        snprintf(lap, sizeof(lap), "Lap %u  %s",
                 stopwatchLapCount, lapTime);
        setLabel(secondaryLabel, lap);
    } else {
        setLabel(secondaryLabel, stopwatchRunning ?
                 "Running - screen may sleep" : "Paused");
    }
}

static void updateSpeedometerView()
{
    const double displaySpeed =
        speedUnit == SpeedUnit::MPH
            ? speedCurrentKph * 0.621371
            : speedCurrentKph;
    const double displayMaximum =
        speedUnit == SpeedUnit::MPH
            ? speedMaximumKph * 0.621371
            : speedMaximumKph;
    const double hours =
        static_cast<double>(speedometerElapsedUs()) /
        3600000000.0;
    const double averageKph =
        hours > 0.0 ? speedDistanceM / 1000.0 / hours : 0.0;
    const double displayAverage =
        speedUnit == SpeedUnit::MPH
            ? averageKph * 0.621371
            : averageKph;
    const double displayDistance =
        speedUnit == SpeedUnit::MPH
            ? speedDistanceM / 1609.344
            : speedDistanceM / 1000.0;
    char speed[24];
    snprintf(speed, sizeof(speed), "%.1f", displaySpeed);
    setLabel(primaryLabel, speed);
    char trip[96];
    snprintf(trip, sizeof(trip),
             "%s  MAX %.1f  AVG %.1f\nTRIP %.2f %s",
             speedUnitName(), displayMaximum, displayAverage,
             displayDistance,
             speedUnit == SpeedUnit::MPH ? "mi" : "km");
    setLabel(secondaryLabel, trip);
    char gps[64];
    const uint32_t satellites = instance.gps.satellites.isValid()
        ? instance.gps.satellites.value() : 0;
    const bool freshLocation =
        instance.gps.location.isValid() &&
        instance.gps.location.age() <= GPS_MAX_FIX_AGE_MS;
    snprintf(gps, sizeof(gps), "%s  //  SAT %u",
             !speedometerRunning
                 ? "STOPPED"
                 : (freshLocation ? "LIVE GPS" : "ACQUIRING"),
             satellites);
    setLabel(statusLabel, gps);
}

static uint64_t timerCurrentRemainingUs()
{
    if (!timerRunning) {
        return timerRemainingUs;
    }
    const int64_t remaining = timerEndsUs - monotonicUs();
    return remaining > 0 ? static_cast<uint64_t>(remaining) : 0ULL;
}

static void updateTimerView()
{
    char buffer[32];
    formatDuration(timerCurrentRemainingUs() / 1000ULL, false,
                   buffer, sizeof(buffer));
    setLabel(primaryLabel, buffer);
    if (timerAlarmVisible) {
        setLabel(secondaryLabel, "TIME UP");
    } else {
        setLabel(secondaryLabel, timerRunning ?
                 "Running - wakes for alarm" : "Paused");
    }
}

static void updateAlarmView()
{
    char time[16];
    snprintf(time, sizeof(time), "%02u:%02u",
             clockAlarmHour, clockAlarmMinute);
    setLabel(primaryLabel, time);
    if (alertRinging && alertSource == AlertSource::CLOCK) {
        setLabel(secondaryLabel, "ALARM RINGING");
        char status[48];
        snprintf(status, sizeof(status), "%s  //  %u%%",
                 alertModeName(),
                 static_cast<unsigned>(alertVolumePercent));
        setLabel(statusLabel, status);
        return;
    }
    if (alarmSnoozeEndsUs > monotonicUs()) {
        const uint32_t seconds = static_cast<uint32_t>(
            (alarmSnoozeEndsUs - monotonicUs()) / 1000000LL);
        char snooze[48];
        snprintf(snooze, sizeof(snooze), "SNOOZED  %u:%02u",
                 seconds / 60U, seconds % 60U);
        setLabel(secondaryLabel, snooze);
    } else {
        setLabel(secondaryLabel, alarmRepeatName());
    }
    const char *field = alarmField == AlarmField::HOUR
        ? "Editing hour"
        : (alarmField == AlarmField::MINUTE
            ? "Editing minute" : "Editing repeat");
    char status[80];
    snprintf(status, sizeof(status), "%s  //  %s",
             clockAlarmEnabled ? "ON" : "OFF", field);
    setLabel(statusLabel, status);
}

static void updateIntervalView()
{
    char time[32];
    formatDuration(
        intervalCurrentRemainingUs() / 1000ULL,
        false, time, sizeof(time));
    setLabel(primaryLabel, time);
    setLabel(secondaryLabel,
             intervalWorkPhase ? "WORK" : "BREAK");
    char detail[80];
    snprintf(detail, sizeof(detail),
             "%um / %um  //  %u rounds",
             intervalWorkMinutes, intervalBreakMinutes,
             intervalRounds);
    setLabel(statusLabel, detail);
}

static void updateStepsView()
{
    char steps[24];
    const uint32_t count = motionSensorReady
        ? instance.sensor.getPedometerCounter() : 0;
    snprintf(steps, sizeof(steps), "%lu",
             static_cast<unsigned long>(count));
    setLabel(primaryLabel, steps);
}

static void updateBatteryView()
{
    const int percent = instance.pmu.getBatteryPercent();
    char percentage[24];
    snprintf(percentage, sizeof(percentage),
             percent >= 0 && percent <= 100 ? "%d%%" : "--%%",
             percent);
    setLabel(primaryLabel, percentage);
    char detail[80];
    snprintf(detail, sizeof(detail), "%.3f V\n%s",
             instance.pmu.getBattVoltage() / 1000.0,
             instance.pmu.isCharging()
                ? "Charging"
                : (instance.pmu.isVbusIn()
                    ? "USB connected" : "On battery"));
    setLabel(secondaryLabel, detail);
    char memory[96];
    snprintf(memory, sizeof(memory), "Heap %uK  //  PSRAM %uK",
             static_cast<unsigned>(ESP.getFreeHeap() / 1024U),
             static_cast<unsigned>(ESP.getFreePsram() / 1024U));
    setLabel(statusLabel, memory);
}

static void updateGpsView()
{
    setLabel(primaryLabel, gpsStatus);

    char detail[128];
    if (gpsAcquiring) {
        const uint32_t seconds = (millis() - gpsStartedMs) / 1000U;
        const uint32_t timeoutSeconds =
            (gpsManualRequest
                ? GPS_MANUAL_TIMEOUT_MS
                : GPS_AUTO_TIMEOUT_MS) / 1000U;
        const uint32_t satellites = instance.gps.satellites.isValid() ?
                                    instance.gps.satellites.value() : 0;
        const uint32_t nmeaSentences =
            instance.gps.passedChecksum();
        const bool receiverData =
            instance.gps.charsProcessed() > gpsCharsAtStart + 20U;
        snprintf(
            detail, sizeof(detail),
            "Searching %us / %us  SAT %u\nReceiver: %s  NMEA %lu",
            seconds, timeoutSeconds, satellites,
            receiverData ? "DATA OK" : "WAITING",
            static_cast<unsigned long>(nmeaSentences));
    } else if (haveFix) {
        if (haveNearest) {
            char distance[24];
            formatDistance(nearestDistanceM, distance, sizeof(distance));
            snprintf(detail, sizeof(detail),
                     "%.5f, %.5f\nNearest%s: %s\n%s %s",
                     lastLatitude, lastLongitude,
                     insideAmsterdam(lastLatitude, lastLongitude) ? "" : " in Amsterdam",
                     nearestName, distance,
                     cardinalDirection(nearestBearingDeg));
        } else {
            snprintf(detail, sizeof(detail), "%.5f, %.5f\nGNSS powered off",
                     lastLatitude, lastLongitude);
        }
    } else {
        snprintf(detail, sizeof(detail), "GNSS powered off");
    }
    setLabel(secondaryLabel, detail);
}

static void updateMapView()
{
    char buffer[64];
    if (!mapStorageReady) {
        snprintf(buffer, sizeof(buffer), "MAP MISSING");
    } else if (!mapPackageReady) {
        snprintf(buffer, sizeof(buffer), "UPLOAD MAP");
    } else if (mapMissingTileCount > 0) {
        snprintf(buffer, sizeof(buffer), "%u MISSING",
                 mapMissingTileCount);
    } else if (mapFollowPosition) {
        snprintf(buffer, sizeof(buffer), "FOLLOWING");
    } else {
        snprintf(buffer, sizeof(buffer), "FOCUS ME");
    }
    setLabel(mapStatusLabel, buffer);
}

static const char *clockFieldName()
{
    switch (clockField) {
    case ClockField::YEAR:   return "Editing year";
    case ClockField::MONTH:  return "Editing month";
    case ClockField::DAY:    return "Editing day";
    case ClockField::HOUR:   return "Editing hour";
    case ClockField::MINUTE: return "Editing minute";
    }
    return "";
}

static void updateClockView()
{
    char timeBuffer[16];
    char dateBuffer[48];
    snprintf(timeBuffer, sizeof(timeBuffer), "%02u:%02u",
             clockHour, clockMinute);
    snprintf(dateBuffer, sizeof(dateBuffer), "%02u / %02u / %04u",
             clockDay, clockMonth, clockYear);
    setLabel(primaryLabel, timeBuffer);
    setLabel(secondaryLabel, dateBuffer);
    setLabel(statusLabel, clockFieldName());
}

static void updateIrView()
{
    setLabel(primaryLabel, tvProfileName());
    if (statusLabel != nullptr && lv_label_get_text(statusLabel)[0] == '\0') {
        setLabel(statusLabel, "Hold for 0.5 sec to send");
    }
}

static void updateWifiApView()
{
    if (!jokeApActive || activeJokeSsid == nullptr) {
        setLabel(statusLabel, "Choose one SSID  //  60 seconds");
        return;
    }
    const uint32_t elapsed = millis() - jokeApStartedMs;
    const uint32_t remaining =
        elapsed >= JOKE_AP_DURATION_MS
            ? 0
            : (JOKE_AP_DURATION_MS - elapsed + 999U) / 1000U;
    char buffer[96];
    snprintf(buffer, sizeof(buffer), "ON: %s  //  %us",
             activeJokeSsid, remaining);
    setLabel(statusLabel, buffer);
}

static void updateCurrentView(bool force)
{
    const uint32_t interval =
        currentView == View::STOPWATCH && stopwatchRunning
            ? 100U
            : (currentView == View::SPEEDOMETER &&
               speedometerRunning ? 500U : 1000U);
    if (!force && millis() - lastUiRefreshMs < interval) {
        return;
    }
    lastUiRefreshMs = millis();

    switch (currentView) {
    case View::WATCH:     updateWatchView(); break;
    case View::MENU:      break;
    case View::NEARBY:    break;
    case View::SHOP:      break;
    case View::STRAINS:   break;
    case View::STRAIN_SHOPS: break;
    case View::SPEEDOMETER: updateSpeedometerView(); break;
    case View::STOPWATCH: updateStopwatchView(); break;
    case View::TIMER:     updateTimerView(); break;
    case View::ALARM:     updateAlarmView(); break;
    case View::INTERVAL:  updateIntervalView(); break;
    case View::STEPS:     updateStepsView(); break;
    case View::BATTERY:   updateBatteryView(); break;
    case View::TORCH:     break;
    case View::GPS:       updateGpsView(); break;
    case View::MAP:       updateMapView(); break;
    case View::CLOCK:     updateClockView(); break;
    case View::IR:        updateIrView(); break;
    case View::SETTINGS:  break;
    case View::WIFI_AP:   updateWifiApView(); break;
    }
    updateBatteryBadge();
    updateRunningAppsLabel();
}

// -----------------------------------------------------------------------------
// Actions
// -----------------------------------------------------------------------------

static void stopJokeAccessPoint()
{
    if (jokeApActive) {
        WiFi.softAPdisconnect(true);
    }
    WiFi.mode(WIFI_OFF);
    jokeApActive = false;
    activeJokeSsid = nullptr;
    jokeApStartedMs = 0;
    updateCurrentView(true);
}

static void startJokeAccessPoint(size_t index)
{
    if (index >= JOKE_SSID_COUNT) {
        return;
    }
    if (jokeApActive) {
        WiFi.softAPdisconnect(true);
    }
    WiFi.mode(WIFI_AP);
    if (!WiFi.softAP(JOKE_SSIDS[index])) {
        WiFi.mode(WIFI_OFF);
        jokeApActive = false;
        activeJokeSsid = nullptr;
        setLabel(statusLabel, "Could not start Wi-Fi");
        return;
    }
    jokeApActive = true;
    activeJokeSsid = JOKE_SSIDS[index];
    jokeApStartedMs = millis();
    instance.vibrator();
    markActivity();
    updateCurrentView(true);
}

static void pollJokeAccessPoint()
{
    if (!jokeApActive) {
        return;
    }
    if (sleepRequested ||
        millis() - jokeApStartedMs >= JOKE_AP_DURATION_MS) {
        stopJokeAccessPoint();
    }
}

static void pollCustomHomeButton()
{
    const bool down = digitalRead(CUSTOM_HOME_BUTTON_PIN) == LOW;
    const uint32_t now = millis();
    if (down && !customButtonWasDown &&
        now - customButtonLastActionMs >= CUSTOM_BUTTON_DEBOUNCE_MS) {
        customButtonLastActionMs = now;
        stopAlert();
        clearNavigationHistory();
        currentView = View::WATCH;
        rotateWatchFaceShop(true);
        buildCurrentView();
    }
    customButtonWasDown = down;
}

static void changeGpsUpdateMode(int8_t amount)
{
    int8_t next = static_cast<int8_t>(gpsUpdateMode) + amount;
    const int8_t count = static_cast<int8_t>(GpsUpdateMode::COUNT);
    if (next < 0) {
        next = count - 1;
    } else if (next >= count) {
        next = 0;
    }
    if (gpsAcquiring && !gpsManualRequest) {
        stopGpsFix("Automatic GNSS stopped");
    }
    gpsUpdateMode = static_cast<GpsUpdateMode>(next);
    nextGpsUpdateUs = 0;
    saveSettings();
}

static void changeScreenTimeout(int8_t amount)
{
    int16_t next = static_cast<int16_t>(screenTimeoutIndex) + amount;
    if (next < 0) {
        next = SCREEN_TIMEOUT_OPTION_COUNT - 1;
    } else if (next >= static_cast<int16_t>(SCREEN_TIMEOUT_OPTION_COUNT)) {
        next = 0;
    }
    screenTimeoutIndex = static_cast<uint8_t>(next);
    saveSettings();
}

static void changeScreenBrightness(int16_t amount)
{
    screenBrightness = static_cast<uint8_t>(
        constrain(static_cast<int16_t>(screenBrightness) + amount, 30, 230));
    instance.setBrightness(screenBrightness);
    saveSettings();
}

static void toggleRaiseToWake()
{
    if (!motionSensorReady) {
        return;
    }
    raiseToWakeEnabled = !raiseToWakeEnabled;
    configureRaiseToWakeSensor();
}

static void toggleStopwatch()
{
    if (stopwatchRunning) {
        stopwatchAccumulatedUs +=
            static_cast<uint64_t>(monotonicUs() - stopwatchStartedUs);
        stopwatchRunning = false;
    } else {
        stopwatchStartedUs = monotonicUs();
        stopwatchRunning = true;
    }
}

static void addStopwatchLap()
{
    if (!stopwatchRunning) {
        return;
    }
    const uint64_t elapsed = stopwatchElapsedUs();
    if (stopwatchLapCount < MAX_STOPWATCH_LAPS) {
        stopwatchLapsUs[stopwatchLapCount++] = elapsed;
    } else {
        for (size_t index = 1; index < MAX_STOPWATCH_LAPS; ++index) {
            stopwatchLapsUs[index - 1] = stopwatchLapsUs[index];
        }
        stopwatchLapsUs[MAX_STOPWATCH_LAPS - 1] = elapsed;
    }
    instance.vibrator();
}

static void resetStopwatch()
{
    stopwatchRunning = false;
    stopwatchStartedUs = 0;
    stopwatchAccumulatedUs = 0;
    stopwatchLapCount = 0;
    memset(stopwatchLapsUs, 0, sizeof(stopwatchLapsUs));
}

static void addTimerSeconds(uint32_t seconds)
{
    stopAlert();
    timerAlarmVisible = false;
    const uint64_t addition = static_cast<uint64_t>(seconds) * 1000000ULL;
    if (timerRunning) {
        timerEndsUs += static_cast<int64_t>(addition);
    } else {
        timerRemainingUs += addition;
    }
}

static void toggleTimer()
{
    stopAlert();
    timerAlarmVisible = false;
    if (timerRunning) {
        timerRemainingUs = timerCurrentRemainingUs();
        timerRunning = false;
    } else if (timerRemainingUs > 0) {
        timerEndsUs = monotonicUs() + static_cast<int64_t>(timerRemainingUs);
        timerRunning = true;
    }
}

static void resetTimer()
{
    stopAlert();
    timerRunning = false;
    timerEndsUs = 0;
    timerRemainingUs = DEFAULT_TIMER_US;
    timerAlarmVisible = false;
}

static uint64_t speedometerElapsedUs()
{
    return speedAccumulatedUs +
           (speedometerRunning
                ? static_cast<uint64_t>(monotonicUs() - speedStartedUs)
                : 0ULL);
}

static void startSpeedometer()
{
    if (speedometerRunning) {
        return;
    }
    speedometerRunning = true;
    speedStartedUs = monotonicUs();
    speedLastSampleMs = 0;
    startGpsFix(false);
}

static void stopSpeedometer()
{
    if (speedometerRunning) {
        speedAccumulatedUs +=
            static_cast<uint64_t>(monotonicUs() - speedStartedUs);
    }
    speedometerRunning = false;
    speedStartedUs = 0;
    speedCurrentKph = 0.0;
    speedLastSampleMs = 0;
    if (gpsAcquiring) {
        instance.powerControl(POWER_GPS, false);
        gpsAcquiring = false;
        gpsManualRequest = false;
        gpsLastDataMs = 0;
        gpsDataRestartCount = 0;
        snprintf(gpsStatus, sizeof(gpsStatus), "Speedometer stopped");
    }
}

static void resetSpeedometer()
{
    const bool restart = speedometerRunning;
    stopSpeedometer();
    speedMaximumKph = 0.0;
    speedDistanceM = 0.0;
    speedAccumulatedUs = 0;
    if (restart) {
        startSpeedometer();
    }
}

static void recordSpeedSample(uint32_t nowMs)
{
    double speed = 0.0;
    if (instance.gps.speed.isValid() &&
        instance.gps.speed.age() <= GPS_MAX_FIX_AGE_MS) {
        speed = instance.gps.speed.kmph();
        if (!isfinite(speed) || speed < 0.8 || speed > 350.0) {
            speed = 0.0;
        }
    }
    if (speedLastSampleMs > 0 && nowMs > speedLastSampleMs) {
        const double seconds =
            static_cast<double>(nowMs - speedLastSampleMs) / 1000.0;
        speedDistanceM += speed / 3.6 * seconds;
    }
    speedLastSampleMs = nowMs;
    speedCurrentKph = speed;
    speedMaximumKph = max(speedMaximumKph, speed);
}

static uint64_t intervalCurrentRemainingUs()
{
    if (!intervalRunning) {
        return intervalRemainingUs;
    }
    const int64_t remaining = intervalEndsUs - monotonicUs();
    return remaining > 0 ? static_cast<uint64_t>(remaining) : 0ULL;
}

static void setIntervalForCurrentPhase()
{
    intervalRemainingUs =
        static_cast<uint64_t>(
            intervalWorkPhase
                ? intervalWorkMinutes
                : intervalBreakMinutes) *
        60ULL * 1000000ULL;
}

static void toggleInterval()
{
    if (intervalRunning) {
        intervalRemainingUs = intervalCurrentRemainingUs();
        intervalRunning = false;
    } else if (intervalRemainingUs > 0) {
        intervalEndsUs =
            monotonicUs() + static_cast<int64_t>(intervalRemainingUs);
        intervalRunning = true;
    }
}

static void resetInterval()
{
    intervalRunning = false;
    intervalWorkPhase = true;
    intervalRounds = 0;
    intervalEndsUs = 0;
    setIntervalForCurrentPhase();
}

static void adjustIntervalMinutes(bool work, int8_t amount)
{
    if (intervalRunning) {
        return;
    }
    uint8_t &value = work ? intervalWorkMinutes : intervalBreakMinutes;
    const uint8_t maximum = work ? 90 : 30;
    int16_t next = static_cast<int16_t>(value) + amount;
    value = static_cast<uint8_t>(constrain(next, 1, maximum));
    setIntervalForCurrentPhase();
    saveSettings();
}

static void handleIntervalExpiry()
{
    if (!intervalRunning || intervalCurrentRemainingUs() > 0) {
        return;
    }
    if (intervalWorkPhase) {
        ++intervalRounds;
    }
    intervalWorkPhase = !intervalWorkPhase;
    setIntervalForCurrentPhase();
    intervalEndsUs =
        monotonicUs() + static_cast<int64_t>(intervalRemainingUs);
    playAlertPulse();
    markActivity();
    updateCurrentView(true);
}

static void changeAlertMode(int8_t amount)
{
    int8_t next = static_cast<int8_t>(alertMode) + amount;
    const int8_t count = static_cast<int8_t>(AlertMode::COUNT);
    if (next < 0) {
        next = count - 1;
    } else if (next >= count) {
        next = 0;
    }
    alertMode = static_cast<AlertMode>(next);
    if (!alertUsesSound()) {
        stopAlertAudio();
    }
    saveSettings();
}

static void changeAlertVolume(int8_t amount)
{
    int16_t next =
        static_cast<int16_t>(alertVolumePercent) +
        static_cast<int16_t>(amount) * ALERT_VOLUME_STEP;
    alertVolumePercent = static_cast<uint8_t>(
        constrain(next, static_cast<int16_t>(ALERT_VOLUME_STEP),
                  static_cast<int16_t>(100)));
    saveSettings();
}

static void changeSpeedUnit(int8_t amount)
{
    int8_t next = static_cast<int8_t>(speedUnit) + amount;
    const int8_t count = static_cast<int8_t>(SpeedUnit::COUNT);
    if (next < 0) {
        next = count - 1;
    } else if (next >= count) {
        next = 0;
    }
    speedUnit = static_cast<SpeedUnit>(next);
    saveSettings();
}

static void changeWatchShopMode(int8_t amount)
{
    int8_t next = static_cast<int8_t>(watchShopMode) + amount;
    const int8_t count = static_cast<int8_t>(WatchShopMode::COUNT);
    if (next < 0) {
        next = count - 1;
    } else if (next >= count) {
        next = 0;
    }
    watchShopMode = static_cast<WatchShopMode>(next);
    rotatingWatchShopIndex = -1;
    rotatingWatchShopChangedMs = 0;
    rotateWatchFaceShop(true);
    saveSettings();
}

static void adjustAlarmField(int8_t amount)
{
    if (alarmField == AlarmField::HOUR) {
        clockAlarmHour = static_cast<uint8_t>(
            (clockAlarmHour + 24 + amount) % 24);
    } else if (alarmField == AlarmField::MINUTE) {
        clockAlarmMinute = static_cast<uint8_t>(
            (clockAlarmMinute + 60 + amount) % 60);
    } else {
        int8_t next =
            static_cast<int8_t>(clockAlarmRepeat) + amount;
        const int8_t count =
            static_cast<int8_t>(AlarmRepeat::COUNT);
        if (next < 0) {
            next = count - 1;
        } else if (next >= count) {
            next = 0;
        }
        clockAlarmRepeat = static_cast<AlarmRepeat>(next);
    }
    saveSettings();
    configureClockAlarm();
}

static void selectNextAlarmField()
{
    alarmField = static_cast<AlarmField>(
        (static_cast<uint8_t>(alarmField) + 1U) % 3U);
}

static void toggleClockAlarm()
{
    stopAlert();
    alarmSnoozeEndsUs = 0;
    clockAlarmEnabled = !clockAlarmEnabled;
    saveSettings();
    configureClockAlarm();
}

static void snoozeClockAlarm()
{
    stopAlert();
    alarmSnoozeEndsUs =
        monotonicUs() +
        static_cast<int64_t>(ALARM_SNOOZE_MINUTES) *
        60LL * 1000000LL;
    buildCurrentView();
}

static bool isLeapYear(uint16_t year)
{
    return (year % 4U == 0U && year % 100U != 0U) || year % 400U == 0U;
}

static uint8_t daysInMonth(uint16_t year, uint8_t month)
{
    static const uint8_t days[] = {
        31, 28, 31, 30, 31, 30, 31, 31, 30, 31, 30, 31
    };
    if (month == 2) {
        return isLeapYear(year) ? 29 : 28;
    }
    return days[month - 1];
}

static void clampClockDay()
{
    const uint8_t maximum = daysInMonth(clockYear, clockMonth);
    if (clockDay > maximum) {
        clockDay = maximum;
    }
}

static void adjustClockField(int8_t amount)
{
    switch (clockField) {
    case ClockField::YEAR:
        if (amount > 0) {
            clockYear = clockYear >= 2099 ? 2020 : clockYear + 1;
        } else {
            clockYear = clockYear <= 2020 ? 2099 : clockYear - 1;
        }
        clampClockDay();
        break;
    case ClockField::MONTH:
        if (amount > 0) {
            clockMonth = clockMonth >= 12 ? 1 : clockMonth + 1;
        } else {
            clockMonth = clockMonth <= 1 ? 12 : clockMonth - 1;
        }
        clampClockDay();
        break;
    case ClockField::DAY: {
        const uint8_t maximum = daysInMonth(clockYear, clockMonth);
        if (amount > 0) {
            clockDay = clockDay >= maximum ? 1 : clockDay + 1;
        } else {
            clockDay = clockDay <= 1 ? maximum : clockDay - 1;
        }
        break;
    }
    case ClockField::HOUR:
        if (amount > 0) {
            clockHour = (clockHour + 1) % 24;
        } else {
            clockHour = clockHour == 0 ? 23 : clockHour - 1;
        }
        break;
    case ClockField::MINUTE:
        if (amount > 0) {
            clockMinute = (clockMinute + 1) % 60;
        } else {
            clockMinute = clockMinute == 0 ? 59 : clockMinute - 1;
        }
        break;
    }
}

static void selectNextClockField()
{
    clockField = static_cast<ClockField>(
        (static_cast<uint8_t>(clockField) + 1U) % 5U);
}

static void saveClock()
{
    instance.rtc.setDateTime(clockYear, clockMonth, clockDay,
                             clockHour, clockMinute, 0);
    instance.rtc.hwClockRead();
    configureClockAlarm();
    clockEditorLoaded = false;
    instance.vibrator();
    clearNavigationHistory();
    currentView = View::WATCH;
    buildCurrentView();
}

static void changeTvProfile(int8_t amount)
{
    const uint8_t count = static_cast<uint8_t>(TvProfile::COUNT);
    int8_t next = static_cast<int8_t>(tvProfile) + amount;
    if (next < 0) {
        next = count - 1;
    } else if (next >= count) {
        next = 0;
    }
    tvProfile = static_cast<TvProfile>(next);
    setLabel(statusLabel, "Hold for 0.5 sec to send");
}

static void sendTvPower()
{
    switch (tvProfile) {
    case TvProfile::LG:
        // Common LG 32-bit power toggle. Exact models can require another code.
        IrSender.sendNECMSB(0x20DF10EFUL, 32, false);
        break;
    case TvProfile::SAMSUNG:
        // Common Samsung 32-bit power toggle.
        IrSender.sendSamsungMSB(0xE0E040BFUL, 32);
        break;
    case TvProfile::SONY:
        // Common Sony TV power toggle; Sony expects the command three times.
        for (uint8_t repeat = 0; repeat < 3; ++repeat) {
            IrSender.sendSonyMSB(0xA90UL, 12);
            delay(45);
        }
        break;
    case TvProfile::COUNT:
        return;
    }
    instance.vibrator();
    setLabel(statusLabel, "Signal sent");
    markActivity();
}

static bool powerUpGpsReceiver(bool forceProbe)
{
    instance.powerControl(POWER_GPS, false);
    delay(80);
    instance.powerControl(POWER_GPS, true);
    if (gpsSerialBaud != 0 && gpsSerialBaud != 38400) {
        Serial1.updateBaudRate(gpsSerialBaud);
    }
    delay(GPS_POWER_SETTLE_MS);

    const bool wasDetected =
        (instance.getDeviceProbe() & HW_GPS_ONLINE) != 0;
    if ((forceProbe || !wasDetected) && !instance.initGPS()) {
        Serial.println("BFWatch GNSS: receiver probe failed");
        if (!wasDetected) {
            instance.powerControl(POWER_GPS, false);
            return false;
        }
    } else if (forceProbe || !wasDetected) {
        const uint32_t detectedBaud = Serial1.baudRate();
        if (detectedBaud != 0) {
            gpsSerialBaud = detectedBaud;
        }
    }

    instance.gps.loop(false);
    gpsLastCharsProcessed = instance.gps.charsProcessed();
    gpsCharsAtStart = gpsLastCharsProcessed;
    gpsLastDataMs = millis();
    gpsLastDiagnosticMs = gpsLastDataMs;
    Serial.printf(
        "BFWatch GNSS: powered model=%s baud=%lu chars=%lu probe=%u\n",
        instance.gps.getModel().c_str(),
        static_cast<unsigned long>(gpsSerialBaud),
        static_cast<unsigned long>(gpsLastCharsProcessed),
        (instance.getDeviceProbe() & HW_GPS_ONLINE) != 0 ? 1U : 0U);
    return true;
}

static void restartStalledGpsReceiver()
{
    ++gpsDataRestartCount;
    const bool forceProbe =
        gpsDataRestartCount >= GPS_MAX_DATA_RESTARTS;
    Serial.printf(
        "BFWatch GNSS: no serial data, restart %u/%u%s\n",
        static_cast<unsigned>(gpsDataRestartCount),
        static_cast<unsigned>(GPS_MAX_DATA_RESTARTS),
        forceProbe ? " with probe" : "");
    powerUpGpsReceiver(forceProbe);
    snprintf(
        gpsStatus, sizeof(gpsStatus),
        "GNSS restart %u/%u - waiting for data",
        static_cast<unsigned>(gpsDataRestartCount),
        static_cast<unsigned>(GPS_MAX_DATA_RESTARTS));
    updateCurrentView(true);
}

static void startGpsFix(bool manualRequest)
{
    if (gpsAcquiring) {
        if (manualRequest) {
            gpsManualRequest = true;
            snprintf(gpsStatus, sizeof(gpsStatus),
                     "GNSS is already updating");
            updateCurrentView(true);
        }
        return;
    }
    if (!powerUpGpsReceiver(false)) {
        snprintf(gpsStatus, sizeof(gpsStatus), "GNSS hardware not detected");
        nextGpsUpdateUs = monotonicUs() + 60LL * 1000000LL;
        updateCurrentView(true);
        return;
    }

    gpsStartedMs = millis();
    gpsDataRestartCount = 0;
    gpsLastDiagnosticMs = gpsStartedMs;
    gpsAcquiring = true;
    gpsManualRequest = manualRequest;
    if (manualRequest) {
        snprintf(gpsStatus, sizeof(gpsStatus),
                 "Move outdoors with a clear view of the sky");
        markActivity();
        updateCurrentView(true);
    } else {
        snprintf(
            gpsStatus, sizeof(gpsStatus),
            speedometerRunning
                ? "Speedometer acquiring GNSS"
                : "Automatic GNSS update");
    }
}

static void stopGpsFix(const char *message)
{
    instance.powerControl(POWER_GPS, false);
    gpsAcquiring = false;
    gpsManualRequest = false;
    gpsLastDataMs = 0;
    gpsLastDiagnosticMs = 0;
    gpsDataRestartCount = 0;
    snprintf(gpsStatus, sizeof(gpsStatus), "%s", message);
    updateCurrentView(true);
}

static void refreshLocationDisplay()
{
    if (currentView == View::MAP) {
        if (mapFollowPosition &&
            insideAmsterdam(lastLatitude, lastLongitude)) {
            if (BFWATCH_MAP_HAS_DETAIL_BOUNDS &&
                mapZoom == BFWATCH_MAP_DETAIL_ZOOM &&
                !insideMapDetail(lastLatitude, lastLongitude) &&
                mapZoom > BFWATCH_MAP_MIN_ZOOM) {
                --mapZoom;
            }
            mapCenterLatitude = lastLatitude;
            mapCenterLongitude = lastLongitude;
            clampMapCenter();
        }
        const uint32_t savedActivityMs = lastActivityMs;
        buildCurrentView();
        lastActivityMs = savedActivityMs;
    } else {
        updateCurrentView(true);
    }
}

static void pollGps()
{
    if (!gpsAcquiring) {
        return;
    }

    const uint32_t processed = instance.gps.loop(false);
    const uint32_t nowMs = millis();
    if (processed != gpsLastCharsProcessed) {
        gpsLastCharsProcessed = processed;
        gpsLastDataMs = nowMs;
    } else if (gpsLastDataMs != 0 &&
               nowMs - gpsLastDataMs >= GPS_DATA_STALL_MS &&
               gpsDataRestartCount < GPS_MAX_DATA_RESTARTS) {
        restartStalledGpsReceiver();
        return;
    }

    if (nowMs - gpsLastDiagnosticMs >= GPS_DIAGNOSTIC_INTERVAL_MS) {
        gpsLastDiagnosticMs = nowMs;
        const uint32_t satellites =
            instance.gps.satellites.isValid()
                ? instance.gps.satellites.value()
                : 0U;
        const uint32_t hdop =
            instance.gps.hdop.isValid()
                ? instance.gps.hdop.value()
                : 0U;
        Serial.printf(
            "BFWatch GNSS: t=%lus chars=%lu nmea=%lu bad=%lu "
            "fixSent=%lu sat=%lu hdop=%lu loc=%u age=%lu\n",
            static_cast<unsigned long>(
                (nowMs - gpsStartedMs) / 1000U),
            static_cast<unsigned long>(
                instance.gps.charsProcessed() - gpsCharsAtStart),
            static_cast<unsigned long>(
                instance.gps.passedChecksum()),
            static_cast<unsigned long>(
                instance.gps.failedChecksum()),
            static_cast<unsigned long>(
                instance.gps.sentencesWithFix()),
            static_cast<unsigned long>(satellites),
            static_cast<unsigned long>(hdop),
            instance.gps.location.isValid() ? 1U : 0U,
            static_cast<unsigned long>(
                instance.gps.location.isValid()
                    ? instance.gps.location.age()
                    : 0U));
    }

    const bool freshSentence =
        instance.gps.charsProcessed() > gpsCharsAtStart + 20U;
    const bool freshLocation =
        instance.gps.location.isValid() &&
        instance.gps.location.age() <= GPS_MAX_FIX_AGE_MS;
    const bool updateDue =
        lastGpsAcceptedMs == 0 ||
        nowMs - lastGpsAcceptedMs >=
            (speedometerRunning ? SPEED_REFRESH_MS : GPS_LIVE_REFRESH_MS);

    if (freshSentence && freshLocation && updateDue) {
        const bool wasManualRequest = gpsManualRequest;
        lastLatitude = instance.gps.location.lat();
        lastLongitude = instance.gps.location.lng();
        lastFixEpoch = readRtcEpoch();
        haveFix = true;
        lastGpsAcceptedMs = nowMs;
        Serial.printf(
            "BFWatch GNSS: fix %.6f,%.6f sat=%u age=%lu\n",
            lastLatitude, lastLongitude,
            instance.gps.satellites.isValid()
                ? static_cast<unsigned>(
                      instance.gps.satellites.value())
                : 0U,
            static_cast<unsigned long>(
                instance.gps.location.age()));
        calculateNearest();
        if (speedometerRunning) {
            recordSpeedSample(nowMs);
            if (lastFixSavedMs == 0 ||
                nowMs - lastFixSavedMs >= GPS_FIX_SAVE_INTERVAL_MS) {
                saveFix();
                lastFixSavedMs = nowMs;
            }
            gpsStartedMs = nowMs;
            snprintf(gpsStatus, sizeof(gpsStatus), "Speed tracking");
            refreshLocationDisplay();
            return;
        }
        if (wasManualRequest ||
            !gpsModeTracksLive() ||
            lastFixSavedMs == 0 ||
            nowMs - lastFixSavedMs >= GPS_FIX_SAVE_INTERVAL_MS) {
            saveFix();
            lastFixSavedMs = nowMs;
        }
        if (wasManualRequest) {
            instance.vibrator();
        }

        const bool inAmsterdam =
            insideAmsterdam(lastLatitude, lastLongitude);
        if (mapFocusRequested) {
            mapFocusRequested = false;
            if (inAmsterdam) {
                nextGpsUpdateUs =
                    monotonicUs() + gpsUpdateIntervalUs();
                stopGpsFix("Location updated");
                focusMapOnCurrentLocation();
                currentView = View::MAP;
                buildCurrentView();
                return;
            }
        }
        if (!wasManualRequest && gpsModeTracksLive() && inAmsterdam) {
            gpsStartedMs = nowMs;
            snprintf(
                gpsStatus, sizeof(gpsStatus), "%s",
                gpsUpdateMode == GpsUpdateMode::AMSTERDAM
                    ? "Amsterdam live tracking"
                    : "Live tracking");
            refreshLocationDisplay();
            return;
        }

        nextGpsUpdateUs = monotonicUs() + gpsUpdateIntervalUs();
        stopGpsFix(inAmsterdam
            ? "Location updated"
            : "Fix saved - outside Amsterdam map");
        refreshLocationDisplay();
        return;
    }

    const uint32_t timeoutMs =
        gpsManualRequest ? GPS_MANUAL_TIMEOUT_MS : GPS_AUTO_TIMEOUT_MS;
    if (nowMs - gpsStartedMs >= timeoutMs) {
        if (speedometerRunning) {
            gpsStartedMs = nowMs;
            gpsDataRestartCount = 0;
            restartStalledGpsReceiver();
            return;
        }
        mapFocusRequested = false;
        nextGpsUpdateUs = monotonicUs() + gpsUpdateIntervalUs();
        stopGpsFix(
            instance.gps.charsProcessed() > gpsCharsAtStart + 20U
                ? "Receiver OK - no satellite fix"
                : "No GNSS data - using saved location");
    }
}

static void pollGpsSchedule()
{
    if (gpsAcquiring) {
        return;
    }
    if (!automaticGpsAllowed()) {
        nextGpsUpdateUs = 0;
        return;
    }
    const int64_t nowUs = monotonicUs();
    if (nextGpsUpdateUs == 0 || nowUs >= nextGpsUpdateUs) {
        startGpsFix(false);
    }
}

static void handleTimerExpiry()
{
    if (!timerRunning || timerCurrentRemainingUs() > 0) {
        return;
    }

    timerRunning = false;
    timerRemainingUs = 0;
    timerAlarmVisible = true;
    startAlert(AlertSource::COUNTDOWN);
    markActivity();
    currentView = View::TIMER;
    buildCurrentView();
}

static void buttonEvent(lv_event_t *event)
{
    markActivity();
    const intptr_t action = reinterpret_cast<intptr_t>(lv_event_get_user_data(event));

    if (action == ACTION_MAP_BACK) {
        navigateBack(View::MENU);
        return;
    }

    if (action == ACTION_OPEN_APPS) {
        clearNavigationHistory();
        currentView = View::MENU;
        buildCurrentView();
        return;
    }

    if (action == 17099) {
        menusGroupOpen = false;
        menusScrollOffset = 0;
        buildCurrentView();
        return;
    }
    if (action == 17000 || action == 17001) {
        menusActiveGroup = action == 17000 ? -1 : -2;
        menusGroupOpen = true;
        menusScrollOffset = 0;
        buildCurrentView();
        return;
    }
    if (action >= 17100 &&
        action < 17100 + ALPHABET_BUCKET_COUNT) {
        menusActiveGroup =
            static_cast<int8_t>(action - 17100);
        menusGroupOpen = true;
        menusScrollOffset = 0;
        buildCurrentView();
        return;
    }

    if (action >= 20000 && action < 20256 &&
        detailShopIndex >= 0) {
        MenuStrainView strain = {};
        if (shopMenuStrain(
                static_cast<size_t>(detailShopIndex),
                static_cast<uint16_t>(action - 20000), strain)) {
            // Preserve the shop detail screen as its own navigation step.
            // This makes Map -> Shop -> Strain unwind through Shop first,
            // while also restoring the shop menu's previous scroll position.
            rememberCurrentView();
            snprintf(selectedStrainName, sizeof(selectedStrainName), "%s",
                     strain.name);
            strainActiveLetter =
                alphabetBucket(selectedStrainName);
            strainLetterOpen = true;
            strainFavouritesOpen = false;
            strainShopsScrollOffset = 0;
            saveSettings();
            rebuildStrainShopOrder();
            currentView = View::STRAIN_SHOPS;
            buildCurrentView();
        }
        return;
    }

    if (action == 15999) {
        strainLetterOpen = true;
        strainFavouritesOpen = true;
        strainsScrollOffset = 0;
        buildCurrentView();
        return;
    }

    if (action >= 16000 &&
        action < 16000 + ALPHABET_BUCKET_COUNT) {
        strainActiveLetter =
            static_cast<uint8_t>(action - 16000);
        strainLetterOpen = true;
        strainFavouritesOpen = false;
        strainsScrollOffset = 0;
        buildCurrentView();
        return;
    }

    if (action >= 10000 &&
        action < 10000 + static_cast<intptr_t>(strainCatalogCount)) {
        const uint32_t catalogIndex =
            static_cast<uint32_t>(action - 10000);
        snprintf(selectedStrainName, sizeof(selectedStrainName), "%s",
                 strainCatalogNames[catalogIndex]);
        strainActiveLetter =
            alphabetBucket(selectedStrainName);
        strainLetterOpen = true;
        strainShopsScrollOffset = 0;
        saveSettings();
        rebuildStrainShopOrder();
        rememberCurrentView();
        currentView = View::STRAIN_SHOPS;
        buildCurrentView();
        return;
    }

    if (action >= 6000 &&
        action < 6000 + static_cast<intptr_t>(BFWATCH_SHOP_COUNT)) {
        detailShopIndex = static_cast<int16_t>(action - 6000);
        shopStrainScrollOffset = 0;
        rememberCurrentView();
        currentView = View::SHOP;
        buildCurrentView();
        return;
    }

    if (action >= static_cast<intptr_t>(View::WATCH) &&
        action <= static_cast<intptr_t>(View::WIFI_AP)) {
        const View requestedView = static_cast<View>(action);
        clearNavigationHistory();
        if (requestedView == View::MAP) {
            openOverviewMap();
            return;
        }
        if (requestedView == View::STRAINS) {
            strainLetterOpen = false;
            strainFavouritesOpen = false;
            strainsScrollOffset = 0;
        }
        if (requestedView == View::NEARBY) {
            menusGroupOpen = false;
            menusScrollOffset = 0;
        }
        currentView = requestedView;
        if (currentView == View::CLOCK) {
            clockEditorLoaded = false;
        }
        buildCurrentView();
        return;
    }

    switch (action) {
    case 100: toggleStopwatch(); break;
    case 101: resetStopwatch(); break;
    case 102: addStopwatchLap(); break;
    case 200: addTimerSeconds(30); break;
    case 201: addTimerSeconds(60); break;
    case 202: toggleTimer(); break;
    case 203: resetTimer(); break;
    case 204: addTimerSeconds(10U * 60U); break;
    case 205: addTimerSeconds(60U * 60U); break;
    case 300:
        currentView = View::GPS;
        buildCurrentView();
        startGpsFix();
        return;
    case 301:
        mapFocusRequested = false;
        nextGpsUpdateUs = monotonicUs() + gpsUpdateIntervalUs();
        stopGpsFix("GNSS cancelled");
        break;
    case 400: adjustClockField(-1); break;
    case 401: selectNextClockField(); break;
    case 402: adjustClockField(1); break;
    case 403: saveClock(); return;
    case 500: changeTvProfile(-1); break;
    case 501: changeTvProfile(1); break;
    case 700:
        if (detailShopIndex >= 0) {
            toggleShopFavourite(detailShopIndex);
            buildCurrentView();
            return;
        }
        break;
    case 701:
        if (detailShopIndex >= 0) {
            const View returnView =
                previousNavigationView(View::NEARBY);
            if (returnView != View::STRAIN_SHOPS &&
                !(returnView == View::MAP &&
                  mapStrainFilterActive)) {
                mapStrainFilterActive = false;
                mapFilteredStockistCount = 0;
            }
            rememberCurrentView();
            openShopOnMap(detailShopIndex);
            return;
        }
        break;
    case 702:
        navigateBack(View::NEARBY);
        return;
    case 800:
        if (mapStrainFilterActive) {
            openSelectedStrainMap();
        } else {
            openOverviewMap();
        }
        return;
    case 801:
        if (mapZoom > BFWATCH_MAP_MIN_ZOOM) {
            --mapZoom;
            buildCurrentView();
        }
        return;
    case 703:
        mapStrainFilterActive = false;
        mapFilteredStockistCount = 0;
        rememberCurrentView();
        openShopOnMap(watchFaceShopIndex());
        return;
    case 802:
        if (mapZoom < BFWATCH_MAP_MAX_ZOOM) {
            const uint8_t nextZoom = mapZoom + 1;
            if (BFWATCH_MAP_HAS_DETAIL_BOUNDS &&
                nextZoom == BFWATCH_MAP_DETAIL_ZOOM &&
                !insideMapDetail(
                    mapCenterLatitude, mapCenterLongitude)) {
                instance.vibrator();
                setLabel(mapStatusLabel, "Z16 AVAILABLE IN CENTRE");
                return;
            }
            ++mapZoom;
            clampMapCenter();
            buildCurrentView();
        }
        return;
    case 803:
        if (haveFix &&
            insideAmsterdam(lastLatitude, lastLongitude)) {
            focusMapOnCurrentLocation();
            buildCurrentView();
            return;
        }
        // A saved home position is expected when arriving in Amsterdam.
        // Acquire a fresh fix, then return directly to a following map.
        mapFocusRequested = true;
        currentView = View::GPS;
        buildCurrentView();
        startGpsFix();
        return;
    case 900: changeGpsUpdateMode(-1); buildCurrentView(); return;
    case 901: changeGpsUpdateMode(1); buildCurrentView(); return;
    case 902: changeScreenTimeout(-1); buildCurrentView(); return;
    case 903: changeScreenTimeout(1); buildCurrentView(); return;
    case 904: changeScreenBrightness(-25); buildCurrentView(); return;
    case 905: changeScreenBrightness(25); buildCurrentView(); return;
    case 906: toggleRaiseToWake(); buildCurrentView(); return;
    case 907: changeAlertMode(-1); buildCurrentView(); return;
    case 908: changeAlertMode(1); buildCurrentView(); return;
    case 909: changeSpeedUnit(-1); buildCurrentView(); return;
    case 910: changeSpeedUnit(1); buildCurrentView(); return;
    case 911:
        if (alertAudioPlaying && !alertRinging) {
            stopAlertAudio();
        } else {
            playAlertPulse();
        }
        return;
    case 912: changeAlertVolume(-1); buildCurrentView(); return;
    case 913: changeAlertVolume(1); buildCurrentView(); return;
    case 914: changeWatchShopMode(-1); buildCurrentView(); return;
    case 915: changeWatchShopMode(1); buildCurrentView(); return;
    case 1000: startJokeAccessPoint(0); return;
    case 1001: startJokeAccessPoint(1); return;
    case 1002: stopJokeAccessPoint(); return;
    case 1100:
        if (speedometerRunning) {
            stopSpeedometer();
        } else {
            startSpeedometer();
        }
        buildCurrentView();
        return;
    case 1101: resetSpeedometer(); buildCurrentView(); return;
    case 1200: adjustAlarmField(-1); buildCurrentView(); return;
    case 1201: selectNextAlarmField(); buildCurrentView(); return;
    case 1202: adjustAlarmField(1); buildCurrentView(); return;
    case 1203: toggleClockAlarm(); buildCurrentView(); return;
    case 1204: stopAlert(); buildCurrentView(); return;
    case 1205: snoozeClockAlarm(); return;
    case 1300: adjustIntervalMinutes(true, -1); buildCurrentView(); return;
    case 1301: adjustIntervalMinutes(true, 1); buildCurrentView(); return;
    case 1302: adjustIntervalMinutes(false, -1); buildCurrentView(); return;
    case 1303: toggleInterval(); buildCurrentView(); return;
    case 1304: resetInterval(); buildCurrentView(); return;
    case 1305: adjustIntervalMinutes(false, 1); buildCurrentView(); return;
    case 1400:
        if (motionSensorReady) {
            instance.sensor.resetPedometer();
            instance.vibrator();
        }
        updateCurrentView(true);
        return;
    case 1502:
        rememberCurrentView();
        openSelectedStrainMap();
        return;
    case 1503:
        navigateBack(View::STRAINS);
        return;
    case 1504:
        toggleSelectedStrainFavourite();
        buildCurrentView();
        return;
    case 1506:
        strainLetterOpen = false;
        strainFavouritesOpen = false;
        strainsScrollOffset = 0;
        buildCurrentView();
        return;
    default: break;
    }

    instance.vibrator();
    updateCurrentView(true);
}

static void mapDragEvent(lv_event_t *event)
{
    lv_indev_t *indev = lv_indev_active();
    if (indev == nullptr) {
        return;
    }

    const lv_event_code_t code = lv_event_get_code(event);
    lv_point_t point = {};
    lv_indev_get_point(indev, &point);

    if (code == LV_EVENT_PRESSED) {
        mapDragStartPoint = point;
        mapDragStartWorldX =
            longitudeToWorldX(mapCenterLongitude, mapZoom);
        mapDragStartWorldY =
            latitudeToWorldY(mapCenterLatitude, mapZoom);
        mapDragging = true;
        markActivity();
        return;
    }

    if (!mapDragging) {
        return;
    }

    const int16_t deltaX = point.x - mapDragStartPoint.x;
    const int16_t deltaY = point.y - mapDragStartPoint.y;
    if (code == LV_EVENT_PRESSING) {
        for (size_t index = 0; index < mapMovableCount; ++index) {
            if (mapMovables[index].object != nullptr) {
                lv_obj_set_pos(mapMovables[index].object,
                               mapMovables[index].x + deltaX,
                               mapMovables[index].y + deltaY);
            }
        }
        markActivity();
    } else if (code == LV_EVENT_RELEASED ||
               code == LV_EVENT_PRESS_LOST) {
        mapDragging = false;
        if (abs(deltaX) < 4 && abs(deltaY) < 4) {
            if (mapZoom >= 13 || mapStrainFilterActive) {
                int32_t closestDistanceSquared = INT32_MAX;
                int16_t closestShop = -1;
                for (size_t index = 0; index < mapMarkerPointCount; ++index) {
                    const MapMarkerPoint &marker = mapMarkerPoints[index];
                    if (marker.shopIndex == UINT16_MAX) {
                        continue;
                    }
                    const int32_t x = point.x - marker.x;
                    const int32_t y = point.y - marker.y;
                    const int32_t distanceSquared = x * x + y * y;
                    const int32_t hitRadius = max(
                        static_cast<int32_t>(14),
                        static_cast<int32_t>(marker.size) / 2 + 6);
                    if (distanceSquared <= hitRadius * hitRadius &&
                        distanceSquared <= closestDistanceSquared) {
                        closestDistanceSquared = distanceSquared;
                        closestShop = static_cast<int16_t>(marker.shopIndex);
                    }
                }
                if (closestShop >= 0) {
                    rememberCurrentView();
                    mapFocusedShopIndex = closestShop;
                    detailShopIndex = closestShop;
                    shopStrainScrollOffset = 0;
                    currentView = View::SHOP;
                    buildCurrentView();
                }
            }
            return;
        }
        const double requestedLongitude =
            worldXToLongitude(mapDragStartWorldX - deltaX, mapZoom);
        const double requestedLatitude =
            worldYToLatitude(mapDragStartWorldY - deltaY, mapZoom);
        mapCenterLongitude = requestedLongitude;
        mapCenterLatitude = requestedLatitude;
        clampMapCenter();
        Serial.printf(
            "Map pan: z=%u strain=%u delta=%d,%d "
            "requested=%.6f,%.6f final=%.6f,%.6f\n",
            static_cast<unsigned>(mapZoom),
            mapStrainFilterActive ? 1U : 0U,
            static_cast<int>(deltaX),
            static_cast<int>(deltaY),
            requestedLatitude, requestedLongitude,
            mapCenterLatitude, mapCenterLongitude);
        mapFollowPosition = false;
        mapCenterInitialized = true;
        buildCurrentView();
    }
}

static void gestureEvent(lv_event_t *event)
{
    (void)event;
    if (currentView == View::MAP) {
        return;
    }
    lv_indev_t *indev = lv_indev_active();
    if (indev == nullptr) {
        return;
    }

    const lv_dir_t direction = lv_indev_get_gesture_dir(indev);
    if (direction == LV_DIR_LEFT && currentView != View::MENU) {
        lv_indev_wait_release(indev);
        clearNavigationHistory();
        currentView = View::MENU;
        buildCurrentView();
    } else if (direction == LV_DIR_RIGHT && currentView != View::WATCH) {
        lv_indev_wait_release(indev);
        clearNavigationHistory();
        currentView = View::WATCH;
        buildCurrentView();
    }
}

static void irPowerEvent(lv_event_t *event)
{
    (void)event;
    sendTvPower();
}

// -----------------------------------------------------------------------------
// Power management
// -----------------------------------------------------------------------------

static uint32_t currentTimeoutMs()
{
    return SCREEN_TIMEOUT_OPTIONS_MS[screenTimeoutIndex];
}

static void enterLowPowerSleep()
{
    if (speedometerRunning) {
        return;
    }
    const bool liveGpsMaySleep =
        gpsAcquiring && !gpsManualRequest && gpsModeTracksLive();
    if (gpsAcquiring && !liveGpsMaySleep) {
        return;
    }
    bool keepAmsterdamGpsWarm = amsterdamGpsWarmHoldAllowed();
    const int64_t amsterdamWarmHoldEndsUs =
        keepAmsterdamGpsWarm
            ? monotonicUs() +
                static_cast<int64_t>(AMSTERDAM_GPS_WARM_HOLD_MS) * 1000LL
            : 0;
    if (gpsAcquiring && !keepAmsterdamGpsWarm) {
        instance.powerControl(POWER_GPS, false);
        gpsAcquiring = false;
        gpsManualRequest = false;
        gpsLastDataMs = 0;
        gpsDataRestartCount = 0;
        nextGpsUpdateUs = 0;
        snprintf(
            gpsStatus, sizeof(gpsStatus), "%s",
            gpsUpdateMode == GpsUpdateMode::AMSTERDAM
                ? "Amsterdam GPS resting to save battery"
                : "Live tracking paused while screen sleeps");
    }

    // Wake for the earliest software timer. Amsterdam Mode also wakes once
    // after its warm-lock window so it can quietly switch the GNSS rail off.
    const auto armSleepTimer = [&](uint64_t gpsWarmRemainingUs) {
        esp_sleep_disable_wakeup_source(ESP_SLEEP_WAKEUP_TIMER);
        uint64_t wakeRemainingUs = gpsWarmRemainingUs;
        const int64_t nowUs = monotonicUs();
        const uint64_t countdownRemaining =
            timerRunning ? timerCurrentRemainingUs() : 0;
        const uint64_t intervalRemaining =
            intervalRunning ? intervalCurrentRemainingUs() : 0;
        const uint64_t snoozeRemaining =
            alarmSnoozeEndsUs > nowUs
                ? static_cast<uint64_t>(alarmSnoozeEndsUs - nowUs)
                : 0;
        for (const uint64_t candidate : {
                 countdownRemaining, intervalRemaining, snoozeRemaining}) {
            if (candidate > 0 &&
                (wakeRemainingUs == 0 || candidate < wakeRemainingUs)) {
                wakeRemainingUs = candidate;
            }
        }
        if (wakeRemainingUs == 0) {
            return false;
        }
        if (wakeRemainingUs < 100000ULL) {
            wakeRemainingUs = 100000ULL;
        }
        esp_sleep_enable_timer_wakeup(wakeRemainingUs);
        return true;
    };
    bool timerWakeEnabled = armSleepTimer(
        keepAmsterdamGpsWarm
            ? static_cast<uint64_t>(AMSTERDAM_GPS_WARM_HOLD_MS) * 1000ULL
            : 0);

    lv_task_handler();
    instance.setBrightness(0);
    delay(25);

    // This is intentionally local rather than instance.lightSleep(). The
    // current LilyGoLib helper wakes the LoRa radio and GNSS on return; BFWatch
    // keeps both rails off unless a feature explicitly needs them.
    instance.powerControl(POWER_DISPLAY_BACKLIGHT, false);
    instance.powerControl(POWER_HAPTIC_DRIVER, false);
    if (!keepAmsterdamGpsWarm) {
        instance.powerControl(POWER_GPS, false);
    }
    instance.powerControl(POWER_RADIO, false);
    instance.powerControl(POWER_SPEAK, false);
    instance.LilyGoDispSPI::sleep();

    instance.pmu.disableIRQ(XPOWERS_AXP2101_ALL_IRQ);
    instance.pmu.clearIrqStatus();
    instance.pmu.enableIRQ(XPOWERS_AXP2101_PKEY_SHORT_IRQ);
    rtc_gpio_pullup_en(static_cast<gpio_num_t>(PMU_INT));
    pinMode(CUSTOM_HOME_BUTTON_PIN, INPUT_PULLUP);
    rtc_gpio_pullup_en(
        static_cast<gpio_num_t>(CUSTOM_HOME_BUTTON_PIN));
    if (clockAlarmEnabled) {
        pinMode(RTC_INT, INPUT_PULLUP);
        rtc_gpio_pullup_en(static_cast<gpio_num_t>(RTC_INT));
    }

    bool sensorWakeArmed =
        raiseToWakeEnabled && motionSensorReady;
    if (sensorWakeArmed) {
        instance.sensor.readIrqStatus();
        delay(1);
        // A stuck-low sensor interrupt would otherwise wake immediately.
        // Excluding it preserves the proven touch/power wake path.
        sensorWakeArmed = digitalRead(SENSOR_INT) != LOW;
    }
    uint64_t wakePins =
        _BV(TP_INT) | _BV(PMU_INT) |
        _BV(CUSTOM_HOME_BUTTON_PIN);
    if (clockAlarmEnabled) {
        wakePins |= _BV(RTC_INT);
    }
    if (sensorWakeArmed) {
        wakePins |= _BV(SENSOR_INT);
    }
#if ESP_IDF_VERSION >= ESP_IDF_VERSION_VAL(5, 0, 0)
    esp_sleep_enable_ext1_wakeup_io(wakePins, ESP_EXT1_WAKEUP_ANY_LOW);
#else
    esp_sleep_enable_ext1_wakeup(wakePins, ESP_EXT1_WAKEUP_ANY_LOW);
#endif

    esp_light_sleep_start();
    esp_sleep_wakeup_cause_t wakeCause = esp_sleep_get_wakeup_cause();
    if (timerWakeEnabled) {
        esp_sleep_disable_wakeup_source(ESP_SLEEP_WAKEUP_TIMER);
        timerWakeEnabled = false;
    }

    // If only the warm-lock timer fired, shut GNSS down and remain asleep.
    // A countdown, interval timer or alarm that is actually due still wakes
    // the display normally.
    if (keepAmsterdamGpsWarm &&
        wakeCause == ESP_SLEEP_WAKEUP_TIMER &&
        monotonicUs() >= amsterdamWarmHoldEndsUs) {
        const int64_t nowUs = monotonicUs();
        const bool softwareAlertDue =
            (timerRunning && timerCurrentRemainingUs() == 0) ||
            (intervalRunning && intervalCurrentRemainingUs() == 0) ||
            (alarmSnoozeEndsUs > 0 && alarmSnoozeEndsUs <= nowUs);
        if (!softwareAlertDue) {
            instance.powerControl(POWER_GPS, false);
            gpsAcquiring = false;
            gpsManualRequest = false;
            gpsLastDataMs = 0;
            gpsLastDiagnosticMs = 0;
            gpsDataRestartCount = 0;
            nextGpsUpdateUs = 0;
            keepAmsterdamGpsWarm = false;
            snprintf(gpsStatus, sizeof(gpsStatus),
                     "Amsterdam GPS resting to save battery");

            timerWakeEnabled = armSleepTimer(0);
            esp_light_sleep_start();
            wakeCause = esp_sleep_get_wakeup_cause();
            if (timerWakeEnabled) {
                esp_sleep_disable_wakeup_source(
                    ESP_SLEEP_WAKEUP_TIMER);
                timerWakeEnabled = false;
            }
        }
    }
    const uint64_t ext1WakePins =
        wakeCause == ESP_SLEEP_WAKEUP_EXT1
            ? esp_sleep_get_ext1_wakeup_status()
            : 0;
    const bool wokeByRaise =
        sensorWakeArmed && (ext1WakePins & _BV(SENSOR_INT)) != 0;
    const bool wokeByHome =
        (ext1WakePins & _BV(CUSTOM_HOME_BUTTON_PIN)) != 0;
    const bool wokeByClock =
        clockAlarmEnabled &&
        (ext1WakePins & _BV(RTC_INT)) != 0;
    if (wokeByClock) {
        lastClockAlarmPollMs = millis() - 500U;
    }
    customButtonWasDown =
        digitalRead(CUSTOM_HOME_BUTTON_PIN) == LOW;

    esp_sleep_disable_wakeup_source(ESP_SLEEP_WAKEUP_EXT1);
    if (wokeByRaise) {
        instance.sensor.readIrqStatus();
    }

    instance.pmu.disableIRQ(XPOWERS_AXP2101_ALL_IRQ);
    instance.pmu.enableIRQ(
        XPOWERS_AXP2101_PKEY_SHORT_IRQ |
        XPOWERS_AXP2101_PKEY_LONG_IRQ |
        XPOWERS_AXP2101_VBUS_INSERT_IRQ |
        XPOWERS_AXP2101_VBUS_REMOVE_IRQ |
        XPOWERS_AXP2101_BAT_CHG_START_IRQ |
        XPOWERS_AXP2101_BAT_CHG_DONE_IRQ);
    instance.pmu.clearIrqStatus();

    instance.LilyGoDispSPI::wakeup();
    instance.powerControl(POWER_DISPLAY_BACKLIGHT, true);
    instance.powerControl(POWER_HAPTIC_DRIVER, true);
    instance.setBrightness(screenBrightness);

    ignorePowerButtonUntilMs = millis() + 600U;
    sleepRequested = false;
    markActivity();
    handleTimerExpiry();
    handleIntervalExpiry();
    pollClockAlarm();
    if (alertRinging) {
        currentView =
            alertSource == AlertSource::CLOCK
                ? View::ALARM : View::TIMER;
        buildCurrentView();
    } else if (wokeByHome) {
        stopAlert();
        clearNavigationHistory();
        currentView = View::WATCH;
        rotateWatchFaceShop(true);
        buildCurrentView();
    } else if (wokeByRaise) {
        clearNavigationHistory();
        currentView = View::WATCH;
        rotateWatchFaceShop(true);
        buildCurrentView();
    } else if (currentView == View::WATCH) {
        rotateWatchFaceShop(true);
        buildCurrentView();
    } else if (currentView == View::TORCH) {
        buildCurrentView();
    } else {
        updateCurrentView(true);
    }
    pollGpsSchedule();
}

// -----------------------------------------------------------------------------
// Map package upload protocol
// -----------------------------------------------------------------------------

static uint32_t updateCrc32(uint32_t crc, const uint8_t *data, size_t length)
{
    for (size_t index = 0; index < length; ++index) {
        crc ^= data[index];
        for (uint8_t bit = 0; bit < 8; ++bit) {
            crc = (crc >> 1) ^ (0xEDB88320UL & (0UL - (crc & 1UL)));
        }
    }
    return crc;
}

static bool makeMapParentDirectories(char *path)
{
    for (char *cursor = path + 1; *cursor != '\0'; ++cursor) {
        if (*cursor != '/') {
            continue;
        }
        *cursor = '\0';
        if (!FFat.exists(path) && !FFat.mkdir(path)) {
            *cursor = '/';
            return false;
        }
        *cursor = '/';
    }
    return true;
}

static bool isMapUploadPath(const char *relativePath)
{
    if (strcmp(relativePath, "map.idx") == 0 ||
        strcmp(relativePath, "logos.idx") == 0 ||
        strcmp(relativePath, "logos.bin") == 0 ||
        strcmp(relativePath, "menus.bin") == 0) {
        return true;
    }
    return strlen(relativePath) == 9 &&
           strncmp(relativePath, "map", 3) == 0 &&
           relativePath[3] >= '0' && relativePath[3] <= '9' &&
           relativePath[4] >= '0' && relativePath[4] <= '9' &&
           strcmp(relativePath + 5, ".bin") == 0;
}

static void receiveMapFile(const char *relativePath, uint32_t expectedSize,
                           uint32_t expectedCrc)
{
    if (!mapStorageReady || strstr(relativePath, "..") != nullptr ||
        !isMapUploadPath(relativePath)) {
        Serial.println("BFMAP_ERROR invalid_path");
        return;
    }

    char fullPath[112];
    snprintf(fullPath, sizeof(fullPath), "/%s", relativePath);
    if (!makeMapParentDirectories(fullPath)) {
        Serial.println("BFMAP_ERROR mkdir_failed");
        return;
    }

    File output = FFat.open(fullPath, FILE_WRITE);
    if (!output) {
        Serial.println("BFMAP_ERROR open_failed");
        return;
    }

    Serial.printf("BFMAP_GO %u\n",
                  static_cast<unsigned>(MAP_UPLOAD_BLOCK_SIZE));
    Serial.flush();

    uint8_t buffer[MAP_UPLOAD_BLOCK_SIZE];
    uint32_t received = 0;
    uint32_t crc = 0xFFFFFFFFUL;
    uint32_t lastDataMs = millis();
    bool writeFailed = false;

    while (received < expectedSize) {
        const size_t blockTarget = min(
            sizeof(buffer), static_cast<size_t>(expectedSize - received));
        size_t blockReceived = 0;
        while (blockReceived < blockTarget) {
            const int available = Serial.available();
            if (available <= 0) {
                if (millis() - lastDataMs > MAP_UPLOAD_TIMEOUT_MS) {
                    output.close();
                    FFat.remove(fullPath);
                    mapUploadActive = true;
                    mapUploadLastActivityMs = millis();
                    Serial.println("BFMAP_ERROR receive_timeout");
                    return;
                }
                delay(1);
                continue;
            }

            const size_t wanted = min(
                static_cast<size_t>(available), blockTarget - blockReceived);
            const size_t count =
                Serial.readBytes(buffer + blockReceived, wanted);
            if (count == 0) {
                continue;
            }
            lastDataMs = millis();
            blockReceived += count;
        }

        if (output.write(buffer, blockReceived) != blockReceived) {
            writeFailed = true;
            break;
        }
        crc = updateCrc32(crc, buffer, blockReceived);
        received += blockReceived;
        if (received < expectedSize) {
            Serial.printf("BFMAP_MORE %lu\n",
                          static_cast<unsigned long>(received));
            Serial.flush();
        }
    }

    output.flush();
    output.close();
    crc ^= 0xFFFFFFFFUL;

    if (writeFailed || received != expectedSize || crc != expectedCrc) {
        FFat.remove(fullPath);
        Serial.printf("BFMAP_ERROR verify_failed %lu %08lX\n",
                      static_cast<unsigned long>(received),
                      static_cast<unsigned long>(crc));
        return;
    }

    Serial.printf("BFMAP_OK %s %lu %08lX\n", relativePath,
                  static_cast<unsigned long>(received),
                  static_cast<unsigned long>(crc));
    markActivity();
}

static void handleMapUploadCommand(const char *line)
{
    if (strcmp(line, "BFMAP_HELLO") == 0) {
        if (!mapStorageReady) {
            Serial.println("BFMAP_ERROR storage_unavailable");
            return;
        }
        mapUploadActive = true;
        mapUploadLastActivityMs = millis();
        Serial.printf("BFMAP_READY %u %u\n",
                      static_cast<unsigned>(FFat.totalBytes()),
                      static_cast<unsigned>(FFat.freeBytes()));
        markActivity();
        return;
    }

    if (strcmp(line, "BFMAP_BEGIN") == 0) {
        if (!mapStorageReady) {
            Serial.println("BFMAP_ERROR storage_unavailable");
            return;
        }
        mapUploadActive = true;
        mapUploadLastActivityMs = millis();
        unloadLogoIndex();
        logoPackageReady = false;
        unloadMenuPackage();
        Serial.println("BFMAP_BEGIN_OK");
        markActivity();
        return;
    }

    if (strcmp(line, "BFMAP_CLEAR") == 0) {
        if (!mapStorageReady) {
            Serial.println("BFMAP_ERROR storage_unavailable");
            return;
        }
        mapUploadActive = true;
        mapUploadLastActivityMs = millis();
        unloadMapPackIndex();
        unloadLogoIndex();
        unloadMenuPackage();
        mapStorageReady = false;
        FFat.end();
        const bool formatted = FFat.format(FFAT_WIPE_QUICK);
        mapStorageReady = FFat.begin(true, "/sd");
        mapPackageReady = false;
        logoPackageReady = false;
        menuPackageReady = false;
        if (formatted && mapStorageReady) {
            Serial.printf("BFMAP_CLEAR_OK %u\n",
                          static_cast<unsigned>(FFat.freeBytes()));
        } else {
            Serial.println("BFMAP_ERROR clear_failed");
        }
        return;
    }

    if (strncmp(line, "BFMAP_PUT ", 10) == 0) {
        char relativePath[96] = {};
        unsigned long size = 0;
        unsigned long crc = 0;
        if (sscanf(line + 10, "%95s %lu %lx",
                   relativePath, &size, &crc) != 3) {
            Serial.println("BFMAP_ERROR malformed_put");
            return;
        }
        mapUploadActive = true;
        mapUploadLastActivityMs = millis();
        receiveMapFile(relativePath, static_cast<uint32_t>(size),
                       static_cast<uint32_t>(crc));
        return;
    }

    if (strcmp(line, "BFMAP_DONE") == 0) {
        mapUploadActive = false;
        mapPackageReady = mapFilesInstalled();
        logoPackageReady = loadLogoIndex();
        menuPackageReady = loadMenuPackage();
        Serial.printf("BFMAP_DONE_OK %u map=%u logos=%u menus=%u\n",
                      static_cast<unsigned>(FFat.usedBytes()),
                      mapPackageReady ? 1U : 0U,
                      logoPackageReady ? 1U : 0U,
                      menuPackageReady ? 1U : 0U);
        if (currentView == View::MAP || currentView == View::SHOP ||
            currentView == View::STRAINS ||
            currentView == View::STRAIN_SHOPS) {
            buildCurrentView();
        }
        return;
    }

    if (strcmp(line, "BFMAP_ABORT") == 0) {
        mapUploadActive = false;
        Serial.println("BFMAP_ABORTED");
    }
}

static void pollMapUpload()
{
    while (Serial.available() > 0) {
        const int incoming = Serial.read();
        if (incoming < 0) {
            break;
        }
        const char character = static_cast<char>(incoming);
        if (character == '\r') {
            continue;
        }
        if (character == '\n') {
            mapUploadLine[mapUploadLineLength] = '\0';
            if (mapUploadLineLength > 0 &&
                strncmp(mapUploadLine, "BFMAP_", 6) == 0) {
                handleMapUploadCommand(mapUploadLine);
            }
            mapUploadLineLength = 0;
            continue;
        }
        if (mapUploadLineLength + 1 < sizeof(mapUploadLine)) {
            mapUploadLine[mapUploadLineLength++] = character;
        } else {
            mapUploadLineLength = 0;
        }
    }
}

// -----------------------------------------------------------------------------
// Arduino lifecycle
// -----------------------------------------------------------------------------

void setup()
{
    Serial.begin(115200);
    delay(50);
    Serial.printf("BFWatch reset reason: %d\n",
                  static_cast<int>(esp_reset_reason()));

    // Keep only the hardware used by BFWatch. LilyGoLib's automatic FATFS
    // setup mounts at /fs, while this LVGL build reads its A: drive from /sd,
    // so BFWatch mounts the dedicated FFat partition itself below.
    const uint32_t disabledHardware =
        NO_SCAN_I2C_DEV | NO_HW_MIC |
        NO_HW_LORA | NO_INIT_FATFS;

    instance.begin(disabledHardware);
    const uint32_t detectedGpsBaud = Serial1.baudRate();
    if (detectedGpsBaud != 0) {
        gpsSerialBaud = detectedGpsBaud;
    }
    Serial.printf(
        "BFWatch GNSS: boot model=%s baud=%lu probe=%u\n",
        instance.gps.getModel().c_str(),
        static_cast<unsigned long>(gpsSerialBaud),
        (instance.getDeviceProbe() & HW_GPS_ONLINE) != 0 ? 1U : 0U);
    // LilyGoLib uses NO_HW_MIC to skip both microphone and PCM-amplifier
    // setup. BFWatch does not need the microphone, so initialize only the
    // I2S speaker explicitly and leave its power rail off between alerts.
    speakerReady = initializeSpeaker();
    Serial.printf("BFWatch audio: amplifier=%u rate=%u\n",
                  speakerReady ? 1U : 0U,
                  speakerReady
                      ? static_cast<unsigned>(
                            instance.player.txSampleRate())
                      : 0U);
    mapStorageReady = FFat.begin(true, "/sd");
    mapPackageReady = mapFilesInstalled();
    logoPackageReady = loadLogoIndex();
    menuPackageReady = loadMenuPackage();
    if (mapStorageReady) {
        Serial.printf(
            "BFWatch FFat: %u total, %u used, map=%u, logos=%u, menus=%u\n",
                      static_cast<unsigned>(FFat.totalBytes()),
                      static_cast<unsigned>(FFat.usedBytes()),
                      mapPackageReady ? 1U : 0U,
                      logoPackageReady ? 1U : 0U,
                      menuPackageReady ? 1U : 0U);
    } else {
        Serial.println("BFWatch FFat mount failed");
    }
    beginLvglHelper(instance);
    registerMapPackFileSystem();

    WiFi.mode(WIFI_OFF);
    instance.powerControl(POWER_RADIO, false);
    instance.powerControl(POWER_SPEAK, false);
    instance.powerControl(POWER_GPS, false);
    instance.setHapticEffects(47);
    IrSender.begin(IR_SEND);

    loadFix();
    loadShopPreferences();
    loadStrainPreferences();
    loadSettings();
    configureRaiseToWakeSensor();
    configureClockAlarm();
    pinMode(CUSTOM_HOME_BUTTON_PIN, INPUT_PULLUP);
    customButtonWasDown =
        digitalRead(CUSTOM_HOME_BUTTON_PIN) == LOW;
    instance.setBrightness(screenBrightness);

    instance.onEvent([](DeviceEvent_t event, void *params, void *userData) {
        (void)event;
        (void)userData;
        if (instance.getPMUEventType(params) == PMU_EVENT_KEY_CLICKED &&
            millis() >= ignorePowerButtonUntilMs) {
            sleepRequested = true;
        }
    }, POWER_EVENT, nullptr);

    snprintf(gpsStatus, sizeof(gpsStatus),
             haveFix ? "Saved location available" : "GNSS is off");

    buildCurrentView();
    lv_task_handler();
}

void loop()
{
    instance.loop();
    pollCustomHomeButton();
    pollMapUpload();
    if (mapUploadActive &&
        millis() - mapUploadLastActivityMs > MAP_UPLOAD_IDLE_TIMEOUT_MS) {
        mapUploadActive = false;
    }
    pollGps();
    pollGpsSchedule();
    pollJokeAccessPoint();
    handleTimerExpiry();
    handleIntervalExpiry();
    pollClockAlarm();
    serviceAlert();
    updateCurrentView(false);

    lv_task_handler();
    delay(5);

    const bool liveGpsMaySleep =
        gpsAcquiring && !gpsManualRequest &&
        gpsModeTracksLive();
    if (!mapUploadActive && !jokeApActive && !alertRinging &&
        !alertAudioPlaying &&
        !speedometerRunning &&
        (sleepRequested ||
         ((!gpsAcquiring || liveGpsMaySleep) &&
          millis() - lastActivityMs >= currentTimeoutMs()))) {
        enterLowPowerSleep();
    }
}
